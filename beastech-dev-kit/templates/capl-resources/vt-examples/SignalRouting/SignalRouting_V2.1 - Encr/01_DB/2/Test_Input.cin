           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igHybErrIndcnReq_0",   /*sig_name*/"isHybErrIndcnReqTelltlSysHybFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/220,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_id*/0x331, /*updatebit_S*/219,   /*updatebit_D*/211         },
           {   /*sigGroup_s*/"igHybErrIndcnReq_0",   /*sig_name*/"isHybErrIndcnReqTelltlElecDrvFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/221,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_id*/0x331, /*updatebit_S*/219,   /*updatebit_D*/211         },
           {   /*sigGroup_s*/"igHybErrIndcnReq_0",   /*sig_name*/"isHybErrIndcnReqTelltlBattTracCutOff_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_id*/0x331, /*updatebit_S*/219,   /*updatebit_D*/211         },
           {   /*sigGroup_s*/"igHybErrIndcnReq_0",   /*sig_name*/"isHybErrIndcnReqTelltlBattTracFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/222,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_id*/0x331, /*updatebit_S*/219,   /*updatebit_D*/211         },
           {   /*sigGroup_s*/"igRowSecRiSideSldPosPerc_0",   /*sig_name*/"isRowSecRiSideSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/50,   /*updatebit_D*/299         },
           {   /*sigGroup_s*/"igRowSecRiSideSldPosPerc_0",   /*sig_name*/"isRowSecRiSideSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/50,   /*updatebit_D*/299         },
           {   /*sigGroup_s*/"igIsgSpdActSgnSafe_0",   /*sig_name*/"isIsgSpdActSgnSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/479,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/473,   /*updatebit_D*/57         },
           {   /*sigGroup_s*/"igIsgSpdActSgnSafe_0",   /*sig_name*/"isIsgSpdActSgnSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/471,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/473,   /*updatebit_D*/57         },
           {   /*sigGroup_s*/"igIsgSpdActSgnSafe_0",   /*sig_name*/"isIsgSpdActSgnSafeIsgSpdActSgn800_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/455,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/473,   /*updatebit_D*/57         },
           {   /*sigGroup_s*/"igIsgSpdActSgnSafe_0",   /*sig_name*/"isIsgSpdActSgnSafeQF_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/475,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/473,   /*updatebit_D*/57         },
           {   /*sigGroup_s*/"igEngNSafe_0",   /*sig_name*/"isEngNSafeEngNGrdt_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/51,   /*updatebit_D*/108         },
           {   /*sigGroup_s*/"igEngNSafe_0",   /*sig_name*/"isEngNSafeEngN_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/51,   /*updatebit_D*/108         },
           {   /*sigGroup_s*/"igEngNSafe_0",   /*sig_name*/"isEngNSafeEngNCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/51,   /*updatebit_D*/108         },
           {   /*sigGroup_s*/"igEngNSafe_0",   /*sig_name*/"isEngNSafeEngNChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/51,   /*updatebit_D*/108         },
           {   /*sigGroup_s*/"igIDcDcActLoSide_0",   /*sig_name*/"isIDcDcActLoSideChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/20,   /*updatebit_D*/368         },
           {   /*sigGroup_s*/"igIDcDcActLoSide_0",   /*sig_name*/"isIDcDcActLoSideCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/20,   /*updatebit_D*/368         },
           {   /*sigGroup_s*/"igIDcDcActLoSide_0",   /*sig_name*/"isIDcDcActLoSideIDcDcActLoSide_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/20,   /*updatebit_D*/368         },
           {   /*sigGroup_s*/"igHWA1EgyCnsGroup_0",   /*sig_name*/"isHWA1EgyCnsGroupIVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/29,   /*updatebit_D*/225         },
           {   /*sigGroup_s*/"igHWA1EgyCnsGroup_0",   /*sig_name*/"isHWA1EgyCnsGroupUval_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/29,   /*updatebit_D*/225         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsIntHighVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsOutOpenCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsIntLowVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsECUFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsOutOverCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsLoadErr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igDimRoofFailrSts_0",   /*sig_name*/"isDimRoofFailrStsResvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igRowSecLeLegRstHeiPosPerc_0",   /*sig_name*/"isRowSecLeLegRstHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/12,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igRowSecLeLegRstHeiPosPerc_0",   /*sig_name*/"isRowSecLeLegRstHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/12,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igBattTLiCell_0",   /*sig_name*/"isBattTLiCellBattTCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1000,   /*updatebit_D*/504         },
           {   /*sigGroup_s*/"igBattTLiCell_0",   /*sig_name*/"isBattTLiCellBattTCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1000,   /*updatebit_D*/504         },
           {   /*sigGroup_s*/"igBattTLiCell_0",   /*sig_name*/"isBattTLiCellBattTCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1000,   /*updatebit_D*/504         },
           {   /*sigGroup_s*/"igRowSecRiHeiPosPerc_0",   /*sig_name*/"isRowSecRiHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x166,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/47,   /*updatebit_D*/491         },
           {   /*sigGroup_s*/"igRowSecRiHeiPosPerc_0",   /*sig_name*/"isRowSecRiHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x166,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/47,   /*updatebit_D*/491         },
           {   /*sigGroup_s*/"igBltLockStAtPassMid_0",   /*sig_name*/"isBltLockStAtPassMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/24,   /*updatebit_D*/220         },
           {   /*sigGroup_s*/"igBltLockStAtPassMid_0",   /*sig_name*/"isBltLockStAtPassMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/24,   /*updatebit_D*/220         },
           {   /*sigGroup_s*/"igBltLockStAtPassMid_0",   /*sig_name*/"isBltLockStAtPassMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/24,   /*updatebit_D*/220         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctVehOri_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctImpctRollAg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashOffroadA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashOffroadRTsevere_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashSideRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctImpctDvy_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashState_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashFrnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashSideLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashRollovr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashRe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashOffroadD_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashOffroadRT_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctCrashPed_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igRecOfImpct_0",   /*sig_name*/"isRecOfImpctImpctDvx_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/33,   /*updatebit_D*/182         },
           {   /*sigGroup_s*/"igPtCluTqCp_0",   /*sig_name*/"isPtCluTqCpReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/21,   /*updatebit_D*/173         },
           {   /*sigGroup_s*/"igPtCluTqCp_0",   /*sig_name*/"isPtCluTqCpReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/21,   /*updatebit_D*/173         },
           {   /*sigGroup_s*/"igPrpsnBrkTqToT_0",   /*sig_name*/"isPrpsnBrkTqToTQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/339,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/337,   /*updatebit_D*/89         },
           {   /*sigGroup_s*/"igPrpsnBrkTqToT_0",   /*sig_name*/"isPrpsnBrkTqToTChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/335,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/337,   /*updatebit_D*/89         },
           {   /*sigGroup_s*/"igPrpsnBrkTqToT_0",   /*sig_name*/"isPrpsnBrkTqToTCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/343,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/337,   /*updatebit_D*/89         },
           {   /*sigGroup_s*/"igPrpsnBrkTqToT_0",   /*sig_name*/"isPrpsnBrkTqToTTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/319,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/337,   /*updatebit_D*/89         },
           {   /*sigGroup_s*/"igPtVehSpdMax_0",   /*sig_name*/"isPtVehSpdMaxChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/27,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igPtVehSpdMax_0",   /*sig_name*/"isPtVehSpdMaxReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/27,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igPtVehSpdMax_0",   /*sig_name*/"isPtVehSpdMaxCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/27,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igDPAModSts_0",   /*sig_name*/"isDPAModStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/8,   /*updatebit_D*/480         },
           {   /*sigGroup_s*/"igDPAModSts_0",   /*sig_name*/"isDPAModStsDPAModSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/8,   /*updatebit_D*/480         },
           {   /*sigGroup_s*/"igDPAModSts_0",   /*sig_name*/"isDPAModStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/8,   /*updatebit_D*/480         },
           {   /*sigGroup_s*/"igPassAirbLampReq_0",   /*sig_name*/"isPassAirbLampReqPassAirbLampEnaReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/33,   /*updatebit_D*/134         },
           {   /*sigGroup_s*/"igPassAirbLampReq_0",   /*sig_name*/"isPassAirbLampReqChgOfPassAirbSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/33,   /*updatebit_D*/134         },
           {   /*sigGroup_s*/"igPassAirbLampReq_0",   /*sig_name*/"isPassAirbLampReqChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/33,   /*updatebit_D*/134         },
           {   /*sigGroup_s*/"igPassAirbLampReq_0",   /*sig_name*/"isPassAirbLampReqPassAirbLampDiReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/33,   /*updatebit_D*/134         },
           {   /*sigGroup_s*/"igPassAirbLampReq_0",   /*sig_name*/"isPassAirbLampReqCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/33,   /*updatebit_D*/134         },
           {   /*sigGroup_s*/"igAccrpedlSts_0",   /*sig_name*/"isAccrpedlStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/57,   /*updatebit_D*/202         },
           {   /*sigGroup_s*/"igAccrpedlSts_0",   /*sig_name*/"isAccrpedlStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/57,   /*updatebit_D*/202         },
           {   /*sigGroup_s*/"igAccrpedlSts_0",   /*sig_name*/"isAccrpedlStsFltSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/57,   /*updatebit_D*/202         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSuperCapMosSts_0",   /*sig_name*/"isSuperCapMosStsBoolean9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/16,   /*updatebit_D*/361         },
           {   /*sigGroup_s*/"igSBWErrReqH1_0",   /*sig_name*/"isSBWErrReqH1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x1c5, /*updatebit_S*/16,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igSBWErrReqH1_0",   /*sig_name*/"isSBWErrReqH1SteerErrReq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x1c5, /*updatebit_S*/16,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igSBWErrReqH1_0",   /*sig_name*/"isSBWErrReqH1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x1c5, /*updatebit_S*/16,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataACnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igBMS2FltStsADataA_0",   /*sig_name*/"isBMS2FltStsADataAData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igSldngdoorRiReAntiPnchFault_0",   /*sig_name*/"isSldngdoorRiReAntiPnchFaultPinchEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/16,   /*updatebit_D*/104         },
           {   /*sigGroup_s*/"igSldngdoorRiReAntiPnchFault_0",   /*sig_name*/"isSldngdoorRiReAntiPnchFaultFltMovngEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/16,   /*updatebit_D*/104         },
           {   /*sigGroup_s*/"igTankTurnModSts_0",   /*sig_name*/"isTankTurnModStsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/319,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/426,   /*updatebit_D*/466         },
           {   /*sigGroup_s*/"igTankTurnModSts_0",   /*sig_name*/"isTankTurnModStsTankTurnModSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/323,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/426,   /*updatebit_D*/466         },
           {   /*sigGroup_s*/"igTankTurnModSts_0",   /*sig_name*/"isTankTurnModStsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/327,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/426,   /*updatebit_D*/466         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/403,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/434,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/422,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/420,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/432,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/446,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/442,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/400,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/440,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/414,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorTRM_0",   /*sig_name*/"isVFCVectorTRMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/443,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsExtFctLowerLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsExtFctRateLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsExtSafeLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsExtFctUpperLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsDrvrSteerOvrd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsLatAgReqNotInRange_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igSteerExtFctSts_0",   /*sig_name*/"isSteerExtFctStsLatCtrlReqNotInRange_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/20,   /*updatebit_D*/426         },
           {   /*sigGroup_s*/"igHudSnsrErr_0",   /*sig_name*/"isHudSnsrErrSnsrErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/1000,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igHudSnsrErr_0",   /*sig_name*/"isHudSnsrErrParChk_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/1000,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndDisSldngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndEndNotSuccssWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndStpDurngMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndPreConNotFulfil_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndDurngDoorMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndStrMovngWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndFltAndPitchWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndDriveOpnDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igSldngLeReWarnInd_0",   /*sig_name*/"isSldngLeReWarnIndFltngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/460         },
           {   /*sigGroup_s*/"igLiExtSwt_0",   /*sig_name*/"isLiExtSwtLiExtFctQf_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igLiExtSwt_0",   /*sig_name*/"isLiExtSwtLiExtFctCntr_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igLiExtSwt_0",   /*sig_name*/"isLiExtSwtLiExtFctReq1_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igLiExtSwt_0",   /*sig_name*/"isLiExtSwtLiExtFctCrc_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igRowSecLeRotSwt2_0",   /*sig_name*/"isRowSecLeRotSwt2BtnModC_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/36         },
           {   /*sigGroup_s*/"igRowSecLeRotSwt2_0",   /*sig_name*/"isRowSecLeRotSwt2BtnModB_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/36         },
           {   /*sigGroup_s*/"igRowSecLeRotSwt2_0",   /*sig_name*/"isRowSecLeRotSwt2BtnModA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/36         },
           {   /*sigGroup_s*/"igAccrPedlLnr_0",   /*sig_name*/"isAccrPedlLnrChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/43,   /*updatebit_D*/188         },
           {   /*sigGroup_s*/"igAccrPedlLnr_0",   /*sig_name*/"isAccrPedlLnrCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/43,   /*updatebit_D*/188         },
           {   /*sigGroup_s*/"igAccrPedlLnr_0",   /*sig_name*/"isAccrPedlLnrAccrPedlRat_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/43,   /*updatebit_D*/188         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsSecondRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsSecondRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsThirdRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsFirstRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsThirdRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igReadLiErrSts_0",   /*sig_name*/"isReadLiErrStsReadLiStsFirstRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/161         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHRM_0",   /*sig_name*/"isVFCVectorHRMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsECUFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsOutOverCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsIntLowVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsLoadErr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsOutOpenCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsIntHighVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igPtnDimRoofFailrSts_0",   /*sig_name*/"isPtnDimRoofFailrStsResvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igDrvrSteerActv_0",   /*sig_name*/"isDrvrSteerActvCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/10,   /*updatebit_D*/298         },
           {   /*sigGroup_s*/"igDrvrSteerActv_0",   /*sig_name*/"isDrvrSteerActvDrvrSteerActv_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/10,   /*updatebit_D*/298         },
           {   /*sigGroup_s*/"igDrvrSteerActv_0",   /*sig_name*/"isDrvrSteerActvChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/10,   /*updatebit_D*/298         },
           {   /*sigGroup_s*/"igDoorDrvrPosnToObst2_0",   /*sig_name*/"isDoorDrvrPosnToObst2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igDoorDrvrPosnToObst2_0",   /*sig_name*/"isDoorDrvrPosnToObst2AngleDeg11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igDoorDrvrPosnToObst2_0",   /*sig_name*/"isDoorDrvrPosnToObst2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igBMS2FltStsADataF_0",   /*sig_name*/"isBMS2FltStsADataFData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/376         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2PanMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2PanMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igSunRoofAndCurtFailr2_0",   /*sig_name*/"isSunRoofAndCurtFailr2PanMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReRi_0",   /*sig_name*/"isMotDynCtrlStsReRiDmcSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/86,   /*updatebit_D*/352         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReRi_0",   /*sig_name*/"isMotDynCtrlStsReRiChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/86,   /*updatebit_D*/352         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReRi_0",   /*sig_name*/"isMotDynCtrlStsReRiCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/86,   /*updatebit_D*/352         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReRi_0",   /*sig_name*/"isMotDynCtrlStsReRiDmcSWInfo_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/86,   /*updatebit_D*/352         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReRi_0",   /*sig_name*/"isMotDynCtrlStsReRiDmcActAppTarTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/86,   /*updatebit_D*/352         },
           {   /*sigGroup_s*/"igHvSysRlySts_0",   /*sig_name*/"isHvSysRlyStsChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/9,   /*updatebit_D*/345         },
           {   /*sigGroup_s*/"igHvSysRlySts_0",   /*sig_name*/"isHvSysRlyStsCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/9,   /*updatebit_D*/345         },
           {   /*sigGroup_s*/"igHvSysRlySts_0",   /*sig_name*/"isHvSysRlyStsHvSysRlySts_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/9,   /*updatebit_D*/345         },
           {   /*sigGroup_s*/"igLatCtrlModCfmd_0",   /*sig_name*/"isLatCtrlModCfmdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/23,   /*updatebit_D*/304         },
           {   /*sigGroup_s*/"igLatCtrlModCfmd_0",   /*sig_name*/"isLatCtrlModCfmdLatCtrlMod_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/23,   /*updatebit_D*/304         },
           {   /*sigGroup_s*/"igLatCtrlModCfmd_0",   /*sig_name*/"isLatCtrlModCfmdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/23,   /*updatebit_D*/304         },
           {   /*sigGroup_s*/"igSBWFltStsH1_0",   /*sig_name*/"isSBWFltStsH1FltStsH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/27,   /*updatebit_D*/347         },
           {   /*sigGroup_s*/"igSBWFltStsH1_0",   /*sig_name*/"isSBWFltStsH1FltStsH2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/27,   /*updatebit_D*/347         },
           {   /*sigGroup_s*/"igSBWFltStsH1_0",   /*sig_name*/"isSBWFltStsH1FltStsR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/27,   /*updatebit_D*/347         },
           {   /*sigGroup_s*/"igSBWFltStsH1_0",   /*sig_name*/"isSBWFltStsH1FltStsR2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/27,   /*updatebit_D*/347         },
           {   /*sigGroup_s*/"igRecOfImpct2_0",   /*sig_name*/"isRecOfImpct2ImpctDvySigned_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x148,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/21,   /*updatebit_D*/229         },
           {   /*sigGroup_s*/"igRecOfImpct2_0",   /*sig_name*/"isRecOfImpct2ImpctDvxSigned_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x148,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/21,   /*updatebit_D*/229         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDL_0",   /*sig_name*/"isVFCVectorSDLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igSwtExtrLi2_0",   /*sig_name*/"isSwtExtrLi2LiExtFctQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igSwtExtrLi2_0",   /*sig_name*/"isSwtExtrLi2LiExtFctCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igSwtExtrLi2_0",   /*sig_name*/"isSwtExtrLi2LiExtFctReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igSwtExtrLi2_0",   /*sig_name*/"isSwtExtrLi2LiExtFctCrc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/449         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtAData2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPrpsnDataEvtA_0",   /*sig_name*/"isPrpsnDataEvtACnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/7,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnPrio_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnPfmncReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnAllwdSts1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnAllwdSts2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igPtGearActtn_0",   /*sig_name*/"isPtGearActtnModReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_id*/0x4ee, /*updatebit_S*/16,   /*updatebit_D*/192         },
           {   /*sigGroup_s*/"igAgDataRaw2Safe_0",   /*sig_name*/"isAgDataRaw2SafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/6,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igAgDataRaw2Safe_0",   /*sig_name*/"isAgDataRaw2SafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/6,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igAgDataRaw2Safe_0",   /*sig_name*/"isAgDataRaw2SafePitchRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/6,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igAgDataRaw2Safe_0",   /*sig_name*/"isAgDataRaw2SafePitchRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/6,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqCntr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqReLe_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqReRi_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqFrntRi_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqChks_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igWinSwtReq_0",   /*sig_name*/"isWinSwtReqFrntLe_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/348         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeYawRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeRollRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeYawRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igAgDataRawSafe_0",   /*sig_name*/"isAgDataRawSafeRollRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/5,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupMotTqQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupMotSpdQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupMotSpd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igRearSteerMotInfoGroup_0",   /*sig_name*/"isRearSteerMotInfoGroupMotTq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/56,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igHWAMotTqGroupH1_0",   /*sig_name*/"isHWAMotTqGroupH1EstimateMotTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/75,   /*updatebit_D*/171         },
           {   /*sigGroup_s*/"igHWAMotTqGroupH1_0",   /*sig_name*/"isHWAMotTqGroupH1TarMotTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/75,   /*updatebit_D*/171         },
           {   /*sigGroup_s*/"igBrkLiReqRegen_0",   /*sig_name*/"isBrkLiReqRegenCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/42,   /*updatebit_D*/306         },
           {   /*sigGroup_s*/"igBrkLiReqRegen_0",   /*sig_name*/"isBrkLiReqRegenOnOff_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/42,   /*updatebit_D*/306         },
           {   /*sigGroup_s*/"igBrkLiReqRegen_0",   /*sig_name*/"isBrkLiReqRegenChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/42,   /*updatebit_D*/306         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igBMS2FltStsADataC_0",   /*sig_name*/"isBMS2FltStsADataCData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igRowSecRiZeroGrvyPosPerc_0",   /*sig_name*/"isRowSecRiZeroGrvyPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/24,   /*updatebit_D*/331         },
           {   /*sigGroup_s*/"igRowSecRiZeroGrvyPosPerc_0",   /*sig_name*/"isRowSecRiZeroGrvyPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/24,   /*updatebit_D*/331         },
           {   /*sigGroup_s*/"igAMBStsHUDLiIllmn_0",   /*sig_name*/"isAMBStsHUDLiIllmnChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_id*/0x331, /*updatebit_S*/1000,   /*updatebit_D*/28         },
           {   /*sigGroup_s*/"igAMBStsHUDLiIllmn_0",   /*sig_name*/"isAMBStsHUDLiIllmnCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_id*/0x331, /*updatebit_S*/1000,   /*updatebit_D*/28         },
           {   /*sigGroup_s*/"igAMBStsHUDLiIllmn_0",   /*sig_name*/"isAMBStsHUDLiIllmnAMBStsHUDLiIllmn_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_id*/0x331, /*updatebit_S*/1000,   /*updatebit_D*/28         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecHostAvailabilityRelOnly_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecCommunicationAvailable_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecReserved2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igEpbAvlSec_0",   /*sig_name*/"isEpbAvlSecHostAvailabilityFull_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/4,   /*updatebit_D*/217         },
           {   /*sigGroup_s*/"igOvrdDecelByDrvr_0",   /*sig_name*/"isOvrdDecelByDrvrChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/378,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igOvrdDecelByDrvr_0",   /*sig_name*/"isOvrdDecelByDrvrOvrdDecelByDrvr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/379,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/378,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igOvrdDecelByDrvr_0",   /*sig_name*/"isOvrdDecelByDrvrCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/378,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved10_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved0_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimACFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimRMFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved8_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimBCFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved9_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimBuckFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimReserved6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBattHwFltStsPrim_0",   /*sig_name*/"isBattHwFltStsPrimMosFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x3d0, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igAccrPedlNotCmpl_0",   /*sig_name*/"isAccrPedlNotCmplPsdSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/242,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/241,   /*updatebit_D*/305         },
           {   /*sigGroup_s*/"igAccrPedlNotCmpl_0",   /*sig_name*/"isAccrPedlNotCmplPsdCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/247,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/241,   /*updatebit_D*/305         },
           {   /*sigGroup_s*/"igAccrPedlNotCmpl_0",   /*sig_name*/"isAccrPedlNotCmplPsdChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/241,   /*updatebit_D*/305         },
           {   /*sigGroup_s*/"igAccrPedlNotCmpl_0",   /*sig_name*/"isAccrPedlNotCmplPsd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/243,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/241,   /*updatebit_D*/305         },
           {   /*sigGroup_s*/"igDrvrSteerWhlHldGroup_0",   /*sig_name*/"isDrvrSteerWhlHldGroupDrvrSteerWhlHldQly_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/41,   /*updatebit_D*/425         },
           {   /*sigGroup_s*/"igDrvrSteerWhlHldGroup_0",   /*sig_name*/"isDrvrSteerWhlHldGroupDrvrSteerWhlHld_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/41,   /*updatebit_D*/425         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeALat1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeYawRateWithCmp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeALatWithCmp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeGrdtOfALgt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeYawRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igAsyDataWithCmpSafe_0",   /*sig_name*/"isAsyDataWithCmpSafeALgt1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/56,   /*updatebit_D*/112         },
           {   /*sigGroup_s*/"igSuspStfnVlvCtrlStsFb_0",   /*sig_name*/"isSuspStfnVlvCtrlStsFbFL_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/32,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igSuspStfnVlvCtrlStsFb_0",   /*sig_name*/"isSuspStfnVlvCtrlStsFbRR_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/32,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igSuspStfnVlvCtrlStsFb_0",   /*sig_name*/"isSuspStfnVlvCtrlStsFbRL_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/32,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igSuspStfnVlvCtrlStsFb_0",   /*sig_name*/"isSuspStfnVlvCtrlStsFbFR_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/32,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthMid_0",   /*sig_name*/"isBltLockStAtRowFrthMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/32,   /*updatebit_D*/228         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthMid_0",   /*sig_name*/"isBltLockStAtRowFrthMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/32,   /*updatebit_D*/228         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthMid_0",   /*sig_name*/"isBltLockStAtRowFrthMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/32,   /*updatebit_D*/228         },
           {   /*sigGroup_s*/"igHWASyncStsGroupH2_0",   /*sig_name*/"isHWASyncStsGroupH2SyncSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/450         },
           {   /*sigGroup_s*/"igHWASyncStsGroupH2_0",   /*sig_name*/"isHWASyncStsGroupH2SyncOvrdIndcn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/450         },
           {   /*sigGroup_s*/"igTrsmClu0Sts_0",   /*sig_name*/"isTrsmClu0StsTrsm0CluSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/355,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/432,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igTrsmClu0Sts_0",   /*sig_name*/"isTrsmClu0StsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/351,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/432,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igTrsmClu0Sts_0",   /*sig_name*/"isTrsmClu0StsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/359,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/432,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeAvert_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/257,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeAVertQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/290,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeALat1Qf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/294,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeALgt_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/240,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafePitchRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeYawRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeRollRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeALat_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/274,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/282,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeYawRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/300,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafePitchRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/288,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeALgt1Qf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/292,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igIntgtIMUDataRawSafe_0",   /*sig_name*/"isIntgtIMUDataRawSafeRollRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/302,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/298,   /*updatebit_D*/402         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthLe_0",   /*sig_name*/"isBltLockStAtRowFrthLeBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/36,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthLe_0",   /*sig_name*/"isBltLockStAtRowFrthLeBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/36,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthLe_0",   /*sig_name*/"isBltLockStAtRowFrthLeBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/36,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igRWA1EgyCnsGroup_0",   /*sig_name*/"isRWA1EgyCnsGroupIVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/26,   /*updatebit_D*/261         },
           {   /*sigGroup_s*/"igRWA1EgyCnsGroup_0",   /*sig_name*/"isRWA1EgyCnsGroupUval_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/26,   /*updatebit_D*/261         },
           {   /*sigGroup_s*/"igFrntWiprLvrCmd2_0",   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCrc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/8,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igFrntWiprLvrCmd2_0",   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/8,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igFrntWiprLvrCmd2_0",   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/8,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igFrntWiprLvrCmd2_0",   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCmd1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/8,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igActvReSplrHallSnsrFlt_0",   /*sig_name*/"isActvReSplrHallSnsrFltHallBFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/484         },
           {   /*sigGroup_s*/"igActvReSplrHallSnsrFlt_0",   /*sig_name*/"isActvReSplrHallSnsrFltHallAFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/484         },
           {   /*sigGroup_s*/"igActvReSplrHallSnsrFlt_0",   /*sig_name*/"isActvReSplrHallSnsrFltHallOutpFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/484         },
           {   /*sigGroup_s*/"igRowSecLeSldPosPerc_0",   /*sig_name*/"isRowSecLeSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/51,   /*updatebit_D*/251         },
           {   /*sigGroup_s*/"igRowSecLeSldPosPerc_0",   /*sig_name*/"isRowSecLeSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/51,   /*updatebit_D*/251         },
           {   /*sigGroup_s*/"igFloatDrivingModSts_0",   /*sig_name*/"isFloatDrivingModStsSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/307,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x1e5, /*updatebit_S*/376,   /*updatebit_D*/496         },
           {   /*sigGroup_s*/"igFloatDrivingModSts_0",   /*sig_name*/"isFloatDrivingModStsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/303,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x1e5, /*updatebit_S*/376,   /*updatebit_D*/496         },
           {   /*sigGroup_s*/"igFloatDrivingModSts_0",   /*sig_name*/"isFloatDrivingModStsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/311,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_id*/0x1e5, /*updatebit_S*/376,   /*updatebit_D*/496         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igBMS2FltStsADataB_0",   /*sig_name*/"isBMS2FltStsADataBData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igRainSnsrDiagc_0",   /*sig_name*/"isRainSnsrDiagcRainSnsrHiTDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/349         },
           {   /*sigGroup_s*/"igRainSnsrDiagc_0",   /*sig_name*/"isRainSnsrDiagcRainSnsrHiVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/349         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSRS_0",   /*sig_name*/"isVFCVectorSRSVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igOHCSecRowBtnErrSts_0",   /*sig_name*/"isOHCSecRowBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igOHCSecRowBtnErrSts_0",   /*sig_name*/"isOHCSecRowBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/66,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/82,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockChkSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/90,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igRWASteerLockChk_0",   /*sig_name*/"isRWASteerLockChkSteerLockDataChk0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/89,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt2_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt3_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt1_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt5_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt4_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igSeatMassgMachHwFailrDrvr_0",   /*sig_name*/"isSeatMassgMachHwFailrDrvrTmrFlt_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_id*/0x1cf, /*updatebit_S*/1000,   /*updatebit_D*/209         },
           {   /*sigGroup_s*/"igBtnStsOHTR_0",   /*sig_name*/"isBtnStsOHTRLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/224         },
           {   /*sigGroup_s*/"igBtnStsOHTR_0",   /*sig_name*/"isBtnStsOHTRLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/224         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorLPOD_0",   /*sig_name*/"isVFCVectorLPODVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdLe_0",   /*sig_name*/"isSeatMassgFctRowThrdLeOnOff_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/281         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdLe_0",   /*sig_name*/"isSeatMassgFctRowThrdLeMassgInten_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/281         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdLe_0",   /*sig_name*/"isSeatMassgFctRowThrdLeMassgProg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/281         },
           {   /*sigGroup_s*/"igSteerLockSts_0",   /*sig_name*/"isSteerLockStsFault_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/14,   /*updatebit_D*/160         },
           {   /*sigGroup_s*/"igSteerLockSts_0",   /*sig_name*/"isSteerLockStsUnit_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/14,   /*updatebit_D*/160         },
           {   /*sigGroup_s*/"igSteerLockSts_0",   /*sig_name*/"isSteerLockStsBolt_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/14,   /*updatebit_D*/160         },
           {   /*sigGroup_s*/"igSteerLockSts_0",   /*sig_name*/"isSteerLockStsSafety_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/14,   /*updatebit_D*/160         },
           {   /*sigGroup_s*/"igTwbrWarnSts_0",   /*sig_name*/"isTwbrWarnStsChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/22,   /*updatebit_D*/385         },
           {   /*sigGroup_s*/"igTwbrWarnSts_0",   /*sig_name*/"isTwbrWarnStsYesNo_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/22,   /*updatebit_D*/385         },
           {   /*sigGroup_s*/"igTwbrWarnSts_0",   /*sig_name*/"isTwbrWarnStsCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/22,   /*updatebit_D*/385         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/432,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/420,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/422,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/443,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/446,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/400,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/440,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/442,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/414,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/434,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/403,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCRPM_0",   /*sig_name*/"isVFCVectorCRPMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igTrsmCluT2_0",   /*sig_name*/"isTrsmCluT2Val_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/23,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igTrsmCluT2_0",   /*sig_name*/"isTrsmCluT2Qf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/23,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igBattFltStsPrim_0",   /*sig_name*/"isBattFltStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igBattFltStsPrim_0",   /*sig_name*/"isBattFltStsPrimBattFltStsPrm_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igBattFltStsPrim_0",   /*sig_name*/"isBattFltStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRR_0",   /*sig_name*/"isVFCVectorWPRRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
