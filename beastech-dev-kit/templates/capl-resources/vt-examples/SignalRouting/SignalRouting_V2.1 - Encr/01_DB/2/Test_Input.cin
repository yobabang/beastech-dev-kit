
variables
{   
    //由basetech测试配置生成，非code-factory生成
    
    //本次生成选中的目标网段为：['ZCU_CANFD2', 'PropulsionCAN', 'CEM_LIN3', 'ZCUD_LIN1', 'ChassisCANFD2', 'ZCUD_CANFD4', 'ZCUD_CAN1', 'ChassisCAN1', 'CEM_LIN1', 'ZCUD_LIN2', 'ZCUD_CANFD3', 'CEM_LIN7', 'CEM_LIN4']
    //本次生成被过滤的源网段为：['ZCU_CANFD1', 'CEM_LIN2', 'ZCUD_LIN3']
    
    const int Event = 1002;
    char NodeName[20] = "ZCUD5";
    LinFrame ZCUD_LIN1.0x36 des_DdsZCUD_Lin1Fr01={dlc=7};
    LinFrame ZCUD_LIN1.0x39 des_AdcZcud_Lin1Fr02={dlc=4};
    LinFrame ZCUD_LIN1.0x13 des_MdmZCUD_Lin1Fr01={dlc=2};
    LinFrame ZCUD_LIN1.0x3b des_AdcZcud_Lin1Fr01={dlc=8};
    LinFrame ZCUD_LIN1.0x1 des_MmdZCUD_Lin1Fr01={dlc=4};
    LinFrame CEM_LIN3.0x20 des_OhcCem_Lin3Fr01={dlc=7};
    LinFrame CEM_LIN3.0x23 des_Srm2Cem_Lin3Fr02={dlc=8};
    LinFrame CEM_LIN3.0x8 des_SigCem_Lin3Fr01={dlc=7};
    LinFrame CEM_LIN3.0x11 des_Srm2Cem_Lin3Fr01={dlc=7};
    LinFrame CEM_LIN3.0x1a des_AwmCem_Lin3Fr01={dlc=3};
    LinFrame CEM_LIN3.0x16 des_OhcCem_Lin3Fr05={dlc=2};
    LinFrame CEM_LIN3.0xe des_Awm2Cem_Lin3SertNrFr01={dlc=4};
    LinFrame CEM_LIN3.0x1c des_OhcCem_Lin3Fr06={dlc=7};
    LinFrame CEM_LIN3.0x14 des_OhcCem_Lin3Fr04={dlc=1};
    LinFrame CEM_LIN3.0x6 des_OhcCem_Lin3Fr10={dlc=7};
    LinFrame CEM_LIN6.0x28 des_BmsCem_Lin6Fr06={dlc=7};
    LinFrame CEM_LIN6.0x20 des_BmsCem_Lin6Fr10={dlc=7};
    LinFrame CEM_LIN6.0x2 des_BmsCem_Lin6Fr01={dlc=8};
    LinFrame CEM_LIN6.0x29 des_BmsCem_Lin6Fr12={dlc=8};
    LinFrame CEM_LIN6.0x16 des_FmdmCem_Lin6Fr01={dlc=1};
    LinFrame CEM_LIN6.0x2a des_BmsCem_Lin6Fr13={dlc=8};
    LinFrame CEM_LIN6.0x18 des_FdmlCem_Lin6Fr01={dlc=1};
    LinFrame CEM_LIN6.0x3 des_BmsCem_Lin6Fr02={dlc=8};
    LinFrame CEM_LIN6.0x26 des_BmsCem_Lin6Fr16={dlc=8};
    LinFrame CEM_LIN6.0x4 des_BmsCem_Lin6Fr03={dlc=7};
    LinFrame CEM_LIN6.0x7 des_BmsCem_Lin6Fr08={dlc=8};
    LinFrame CEM_LIN6.0x21 des_BmsCem_Lin6Fr11={dlc=4};
    LinFrame CEM_LIN6.0x9 des_BmsCem_Lin6Fr04={dlc=7};
    LinFrame CEM_LIN6.0x6 des_BmsCem_Lin6Fr05={dlc=7};
    LinFrame CEM_LIN6.0x10 des_BmsCem_Lin6Fr09={dlc=8};
    LinFrame CEM_LIN6.0x8 des_BmsCem_Lin6Fr07={dlc=8};
    LinFrame CEM_LIN6.0x24 des_BmsCem_Lin6Fr14={dlc=8};
    LinFrame CEM_LIN6.0x25 des_BmsCem_Lin6Fr15={dlc=8};
    LinFrame CEM_LIN6.0x27 des_BmsCem_Lin6Fr17={dlc=8};
    LinFrame CEM_LIN1.0x2c des_RlsmCem_Lin1Fr02={dlc=8};
    LinFrame CEM_LIN1.0x2 des_RlsmCem_Lin1Fr03={dlc=8};
    LinFrame CEM_LIN1.0x25 des_WmmCem_Lin1Fr01={dlc=4};
    LinFrame CEM_LIN1.0x15 des_RlsmCem_Lin1Fr01={dlc=8};
    LinFrame CEM_LIN1.0x3 des_RlsmCem_Lin1Fr04={dlc=7};
    LinFrame CEM_LIN1.0x10 des_IrmmCem_Lin1Fr01={dlc=4};
    LinFrame CEM_LIN1.0x13 des_IrmmCem_Lin1Fr02={dlc=8};
    LinFrame CEM_LIN4.0xc des_FtksCem_Lin4Fr01={dlc=8};
    LinFrame CEM_LIN4.0x20 des_LsmCem_Lin4Fr01={dlc=5};
    LinFrame ZCUD_LIN2.0x1 des_HcmlZcud_Lin2Fr01={dlc=7};
    LinFrame ZCUD_LIN2.0x2 des_HcmrZcud_Lin2Fr01={dlc=7};
    LinFrame CEM_LIN7.0x11 des_PosmCem_Lin7Fr01={dlc=8};
    LinFrame CEM_LIN7.0xf des_TCSCem_Lin7Fr03={dlc=8};
    LinFrame CEM_LIN7.0xa des_TCSCem_Lin7Fr02={dlc=8};
    Const int  Num_LIN=48;

    message 0x1 HighPriority_Msg1= {FDF=1,BRS=1,dlc = 15};
    message 0x7FE LowPriority_Msg1= {FDF=1,BRS=1,dlc = 15};
    message PropulsionCAN.0x000 des_PropulsionCAN_0x000;
    message ChassisCAN1.0x000 des_ChassisCAN1_0x000;
    message ZCU_CANFD1.0x000 des_ZCU_CANFD1_0x000;
    message ZCUD_CANFD3.0x000 des_ZCUD_CANFD3_0x000;
    message ChassisCANFD2.0x000 des_ChassisCANFD2_0x000;
    message ZCUD_CAN1.0x000 des_ZCUD_CAN1_0x000;
    message ZCUD_CANFD4.0x000 des_ZCUD_CANFD4_0x000;
    message ZCU_CANFD2.0x000 des_ZCU_CANFD2_0x000;
    message BodyExposedCAN.0x000 des_BodyExposedCAN_0x000;
    const int network_quantity=18;
    dword SignaleRoutingTime=5;
    int network_num;
    int Encoding=2;

    struct gFrame{
    char des_frame[100];
    int des_cyc;
    int des_id;   
    int des_slotid_fr;
    int des_basecycle_fr;
    int des_repetition_fr;
    int des_dlc;
  };
  
    //data for Signal routing message check
    struct Demo_signal_frame{ 
    char des_can[100];
    char networktype[20];
    int SumAll;
    struct gFrame GFrame[500];
  };
        
    struct Demo_signal_frame test_sig_frame[network_quantity]={

   {
       /*des_channels*/  "ZCUD_LIN1",
       /*networktype*/  "LIN",
       1,
       {
           {/*des_frame*/"ZCUDZCUD_Lin1Fr01",   /*des_cyc*/1000,   /*des_id*/3,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           }
       }
   },
   {
       /*des_channels*/  "CEM_LIN3",
       /*networktype*/  "LIN",
       4,
       {
           {/*des_frame*/"ZCUDCem_Lin3Fr12",   /*des_cyc*/1000,   /*des_id*/36,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDCem_Lin3Fr01",   /*des_cyc*/1000,   /*des_id*/0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           },
           {/*des_frame*/"ZCUDCem_Lin3Fr06",   /*des_cyc*/1000,   /*des_id*/29,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           },
           {/*des_frame*/"ZCUDCem_Lin3Fr04",   /*des_cyc*/1000,   /*des_id*/7,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "CEM_LIN2",
       /*networktype*/  "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_channels*/  "CEM_LIN6",
       /*networktype*/  "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_channels*/  "CEM_LIN1",
       /*networktype*/  "LIN",
       2,
       {
           {/*des_frame*/"ZCUDCem_Lin1Fr02",   /*des_cyc*/1000,   /*des_id*/7,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           },
           {/*des_frame*/"ZCUDCem_Lin1Fr01",   /*des_cyc*/1000,   /*des_id*/5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/6    
           }
       }
   },
   {
       /*des_channels*/  "CEM_LIN4",
       /*networktype*/  "LIN",
       1,
       {
           {/*des_frame*/"ZCUDCem_Lin4Fr10",   /*des_cyc*/1000,   /*des_id*/13,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "ZCUD_LIN2",
       /*networktype*/  "LIN",
       2,
       {
           {/*des_frame*/"ZcudZcud_Lin2Fr01",   /*des_cyc*/1000,   /*des_id*/3,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           },
           {/*des_frame*/"ZcudZcud_Lin2Fr02",   /*des_cyc*/1000,   /*des_id*/4,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           }
       }
   },
   {
       /*des_channels*/  "ZCUD_LIN3",
       /*networktype*/  "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_channels*/  "CEM_LIN7",
       /*networktype*/  "LIN",
       3,
       {
           {/*des_frame*/"ZCUDCem_Lin7Fr03",   /*des_cyc*/1000,   /*des_id*/33,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/7    
           },
           {/*des_frame*/"ZCUDCem_Lin7Fr02",   /*des_cyc*/1000,   /*des_id*/26,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDCem_Lin7Fr01",   /*des_cyc*/1000,   /*des_id*/16,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "PropulsionCAN",
       /*networktype*/  "CAN",
       3,
       {
           {/*des_frame*/"ZcudPropFr03",   /*des_cyc*/50,   /*des_id*/0x19d,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudPropFr12",   /*des_cyc*/100,   /*des_id*/0x160,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudPropFr21",   /*des_cyc*/100,   /*des_id*/0x162,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "ChassisCAN1",
       /*networktype*/  "CAN",
       6,
       {
           {/*des_frame*/"ZcudChas1Fr12",   /*des_cyc*/50,   /*des_id*/0x169,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudChas1Fr07",   /*des_cyc*/15,   /*des_id*/0x65,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudChas1Fr21",   /*des_cyc*/60,   /*des_id*/0x171,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudChas1Fr30",   /*des_cyc*/30,   /*des_id*/0x1f0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudChas1Fr28",   /*des_cyc*/80,   /*des_id*/0x360,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZcudChas1Fr22",   /*des_cyc*/170,   /*des_id*/0x463,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "ZCU_CANFD1",
       /*networktype*/  "CAN",
       0,
       {
           0
       }
   },
   {
       /*des_channels*/  "ZCUD_CANFD3",
       /*networktype*/  "CAN",
       2,
       {
           {/*des_frame*/"ZcudZCUDCANFD3Fr02",   /*des_cyc*/50,   /*des_id*/0x153,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudZCUDCANFD3Fr06",   /*des_cyc*/100,   /*des_id*/0x239,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           }
       }
   },
   {
       /*des_channels*/  "ChassisCANFD2",
       /*networktype*/  "CAN",
       9,
       {
           {/*des_frame*/"ZcudChassisCANFD2Fr008",   /*des_cyc*/30,   /*des_id*/0xe5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr003",   /*des_cyc*/20,   /*des_id*/0xdf,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr004",   /*des_cyc*/40,   /*des_id*/0x13c,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr015",   /*des_cyc*/450,   /*des_id*/0x35c,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr016",   /*des_cyc*/200,   /*des_id*/0x2a4,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr010",   /*des_cyc*/100,   /*des_id*/0x23d,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr006",   /*des_cyc*/60,   /*des_id*/0x16f,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr002",   /*des_cyc*/10,   /*des_id*/0x4f,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudChassisCANFD2Fr001",   /*des_cyc*/10,   /*des_id*/0x86,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           }
       }
   },
   {
       /*des_channels*/  "ZCUD_CAN1",
       /*networktype*/  "CAN",
       30,
       {
           {/*des_frame*/"ZCUDZCUDCAN1Fr24",   /*des_cyc*/100,   /*des_id*/0x206,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr40",   /*des_cyc*/100,   /*des_id*/0x228,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr38",   /*des_cyc*/30,   /*des_id*/0x118,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr74",   /*des_cyc*/70,   /*des_id*/0x271,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr78",   /*des_cyc*/50,   /*des_id*/0x1af,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr52",   /*des_cyc*/30,   /*des_id*/0x121,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr48",   /*des_cyc*/100,   /*des_id*/0x209,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr65",   /*des_cyc*/60,   /*des_id*/0x215,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr56",   /*des_cyc*/135,   /*des_id*/0x325,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr26",   /*des_cyc*/85,   /*des_id*/0x32f,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr18",   /*des_cyc*/Event,   /*des_id*/0x181,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"CemBodyFr137",   /*des_cyc*/55,   /*des_id*/0x196,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr13",   /*des_cyc*/40,   /*des_id*/0x366,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr57",   /*des_cyc*/120,   /*des_id*/0x264,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"CEMBodyFr139",   /*des_cyc*/20,   /*des_id*/0x51,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr77",   /*des_cyc*/100,   /*des_id*/0x214,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr32",   /*des_cyc*/25,   /*des_id*/0x143,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr45",   /*des_cyc*/420,   /*des_id*/0x351,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr69",   /*des_cyc*/175,   /*des_id*/0x310,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr27",   /*des_cyc*/10,   /*des_id*/0x54,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr49",   /*des_cyc*/20,   /*des_id*/0x314,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr31",   /*des_cyc*/40,   /*des_id*/0x78,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr37",   /*des_cyc*/20,   /*des_id*/0x76,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr54",   /*des_cyc*/100,   /*des_id*/0x127,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr96",   /*des_cyc*/70,   /*des_id*/0x235,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr70",   /*des_cyc*/70,   /*des_id*/0x99,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr21",   /*des_cyc*/800,   /*des_id*/0x398,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr53",   /*des_cyc*/60,   /*des_id*/0x490,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr03",   /*des_cyc*/40,   /*des_id*/0xe0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           },
           {/*des_frame*/"ZCUDZCUDCAN1Fr50",   /*des_cyc*/800,   /*des_id*/0x471,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/8    
           }
       }
   },
   {
       /*des_channels*/  "ZCUD_CANFD4",
       /*networktype*/  "CAN",
       4,
       {
           {/*des_frame*/"ZcudZCUDCANFD4Fr07",   /*des_cyc*/10,   /*des_id*/0x50,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudZCUDCANFD4Fr06",   /*des_cyc*/20,   /*des_id*/0x100,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudZCUDCANFD4Fr04",   /*des_cyc*/100,   /*des_id*/0x2c0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZcudZCUDCANFD4Fr02",   /*des_cyc*/50,   /*des_id*/0x1c0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           }
       }
   },
   {
       /*des_channels*/  "ZCU_CANFD2",
       /*networktype*/  "CAN",
       39,
       {
           {/*des_frame*/"ZCUDZCUCANFD2Fr07",   /*des_cyc*/10,   /*des_id*/0x5a,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr02",   /*des_cyc*/1000,   /*des_id*/0x4b1,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr17",   /*des_cyc*/50,   /*des_id*/0x1e5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr15",   /*des_cyc*/40,   /*des_id*/0x180,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr08",   /*des_cyc*/20,   /*des_id*/0x132,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr67",   /*des_cyc*/100,   /*des_id*/0x2d1,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr68",   /*des_cyc*/30,   /*des_id*/0x141,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr28",   /*des_cyc*/150,   /*des_id*/0x323,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr26",   /*des_cyc*/80,   /*des_id*/0x281,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr25",   /*des_cyc*/60,   /*des_id*/0x220,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr23",   /*des_cyc*/100,   /*des_id*/0x2e3,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr56",   /*des_cyc*/1000,   /*des_id*/0x4c6,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr01",   /*des_cyc*/1000,   /*des_id*/0x489,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr66",   /*des_cyc*/Event,   /*des_id*/0x53,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr16",   /*des_cyc*/50,   /*des_id*/0x1c5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr57",   /*des_cyc*/1000,   /*des_id*/0x4d1,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr53",   /*des_cyc*/1000,   /*des_id*/0x4c3,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr19",   /*des_cyc*/100,   /*des_id*/0x2e5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr03",   /*des_cyc*/1000,   /*des_id*/0x4b5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr38",   /*des_cyc*/200,   /*des_id*/0x331,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr13",   /*des_cyc*/30,   /*des_id*/0x80,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr75",   /*des_cyc*/50,   /*des_id*/0x1cf,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr50",   /*des_cyc*/450,   /*des_id*/0x3d0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr58",   /*des_cyc*/1000,   /*des_id*/0x4ee,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr14",   /*des_cyc*/30,   /*des_id*/0x170,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr20",   /*des_cyc*/100,   /*des_id*/0x2e0,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr52",   /*des_cyc*/1000,   /*des_id*/0x4c2,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr74",   /*des_cyc*/1000,   /*des_id*/0x4bb,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr69",   /*des_cyc*/70,   /*des_id*/0x25f,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr27",   /*des_cyc*/150,   /*des_id*/0x322,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr51",   /*des_cyc*/1000,   /*des_id*/0x4c1,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr71",   /*des_cyc*/450,   /*des_id*/0x3b5,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr18",   /*des_cyc*/Event,   /*des_id*/0x43,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr47",   /*des_cyc*/300,   /*des_id*/0x371,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr49",   /*des_cyc*/400,   /*des_id*/0x380,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr48",   /*des_cyc*/350,   /*des_id*/0x390,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr21",   /*des_cyc*/100,   /*des_id*/0x2e2,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr39",   /*des_cyc*/250,   /*des_id*/0x361,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           },
           {/*des_frame*/"ZCUDZCUCANFD2Fr77",   /*des_cyc*/700,   /*des_id*/0x40a,   /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,   /*des_repetition_fr*/0,  /*des_dlc*/64    
           }
       }
   },
   {
       /*des_channels*/  "BodyExposedCAN",
       /*networktype*/  "CAN",
       0,
       {
           0
       }
   }
};//data for Signal routing test
  struct gSignal{
    char sig_name[100];
    char scr_can[100];
    char scr_network_type[100];
    int scr_slotid_fr;
    int scr_basecycle_fr;
    int scr_repetition_fr;
    int scr_startbit;
    int sig_length;
    int des_slotid_fr;
    int des_basecycle_fr;
    int des_repetition_fr;
    int des_startbit;
    int scr_cyc;
    int scr_id;
    int scr_dlc;
    int des_cyc;
    int des_id;  
    int updatebit; //source
    int des_updatebit;
    qword InitValue; 
  };
  
 //data for Signal routing test
  struct Demo_signal{ 
    char des_can[100]; 
    char des_networktype[100];
    int sum;
    struct gSignal GSignal[4000];
  };
    
  struct Demo_signal test_sig[network_quantity]={
   {
       /*des_can*/ "ZCUD_LIN1",
       /*networktype*/ "LIN",
       1,
       {
           {   /*sig_name*/"isDrvrSeatSideSpprtSetg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/258,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/3, /*src_updatebit*/256,   /*des_updatebit*/1000,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "CEM_LIN3",
       /*networktype*/ "LIN",
       9,
       {
           {   /*sig_name*/"isActvReSplrHldSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/497,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/36, /*src_updatebit*/496,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isBltRmnTelltl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/90,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0, /*src_updatebit*/89,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtCtrlReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/356,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/29, /*src_updatebit*/354,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtIninSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/337,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/29, /*src_updatebit*/336,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofCtrlReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x350,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/42,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtCtrlReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/6,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/29, /*src_updatebit*/165,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtIninSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/153,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/29, /*src_updatebit*/152,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtIninSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/431,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0, /*src_updatebit*/430,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSunCurtCtrlReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x350,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/45,   /*des_updatebit*/1000,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "CEM_LIN2",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN6",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN1",
       /*networktype*/ "LIN",
       5,
       {
           {   /*sig_name*/"isStreamingMirrImgAdjmt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/179,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isStreamingMirrPosnAdjmt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/187,   /*des_updatebit*/1000,      /*initvalue*/3         },
           {   /*sig_name*/"isStreamingMirrSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/186,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/185,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isStreamingMirrBriAdjmt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/69,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/7, /*src_updatebit*/65,   /*des_updatebit*/1000,      /*initvalue*/10         },
           {   /*sig_name*/"isStreamingMirrBriAutoAdjmt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/178,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/5, /*src_updatebit*/177,   /*des_updatebit*/1000,      /*initvalue*/1         }
       }
   },
   {
       /*des_can*/ "CEM_LIN4",
       /*networktype*/ "LIN",
       1,
       {
           {   /*sig_name*/"isHmiMaxDefrst_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/13, /*src_updatebit*/24,   /*des_updatebit*/1000,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "ZCUD_LIN2",
       /*networktype*/ "LIN",
       4,
       {
           {   /*sig_name*/"isWelcomeGoodbyeModeReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/455,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/3, /*src_updatebit*/451,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isLvlgSwtSetReqLvlgSwtSetReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/4, /*src_updatebit*/192,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isLvlgSwtSetReqChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/4, /*src_updatebit*/192,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isLvlgSwtSetReqCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/4, /*src_updatebit*/192,   /*des_updatebit*/1000,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "ZCUD_LIN3",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN7",
       /*networktype*/ "LIN",
       5,
       {
           {   /*sig_name*/"isTelmThermoTankConstTempSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/399,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x42,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/33, /*src_updatebit*/397,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isTelmThermoTankT_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/255,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x110,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/26, /*src_updatebit*/313,   /*des_updatebit*/1000,      /*initvalue*/250         },
           {   /*sig_name*/"isHMIThermostatSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/363,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/33, /*src_updatebit*/320,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isHMIThermoTankDoorOpen_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/260,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/26, /*src_updatebit*/224,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiThermoTSteDeoSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/176,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x1c3,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/16, /*src_updatebit*/184,   /*des_updatebit*/1000,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "PropulsionCAN",
       /*networktype*/ "CAN",
       8,
       {
           {   /*sig_name*/"isSecBattSocSoc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/303,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x19d, /*src_updatebit*/313,   /*des_updatebit*/38,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBattSocChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/309,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x19d, /*src_updatebit*/313,   /*des_updatebit*/38,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBattSocCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/317,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x19d, /*src_updatebit*/313,   /*des_updatebit*/38,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbTEstimdAmbTEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x160, /*src_updatebit*/128,   /*des_updatebit*/59,      /*initvalue*/700         },
           {   /*sig_name*/"isAmbTEstimdQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x160, /*src_updatebit*/128,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBattSoh_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/327,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x19d, /*src_updatebit*/333,   /*des_updatebit*/39,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptmtAirTEstimdExtdComptmtT_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x162, /*src_updatebit*/90,   /*des_updatebit*/58,      /*initvalue*/600         },
           {   /*sig_name*/"isCmptmtAirTEstimdExtdQlyFlg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x162, /*src_updatebit*/90,   /*des_updatebit*/58,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "ChassisCAN1",
       /*networktype*/ "CAN",
       18,
       {
           {   /*sig_name*/"isSecBattRemainTimeToEmpty_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/287,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x169, /*src_updatebit*/288,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isLimnIndcnSecDcDc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/15,   /*des_id*/0x65, /*src_updatebit*/309,   /*des_updatebit*/20,      /*initvalue*/0         },
           {   /*sig_name*/"isSecULoWarnLvPwrErrULoWarn_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/399,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x171, /*src_updatebit*/318,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isSecULoWarnLvPwrErrLVPwrSplyErrSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/387,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x171, /*src_updatebit*/318,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isSecULoWarnLvPwrErrCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x171, /*src_updatebit*/318,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isSecULoWarnLvPwrErrChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x171, /*src_updatebit*/318,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvModReqForChampnMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x140,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x1f0, /*src_updatebit*/188,   /*des_updatebit*/52,      /*initvalue*/0         },
           {   /*sig_name*/"isISecDcDcActLoSideIDcDcActLoSide_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/263,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x169, /*src_updatebit*/1,   /*des_updatebit*/47,      /*initvalue*/0         },
           {   /*sig_name*/"isISecDcDcActLoSideCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/275,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x169, /*src_updatebit*/1,   /*des_updatebit*/47,      /*initvalue*/0         },
           {   /*sig_name*/"isISecDcDcActLoSideChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/267,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x169, /*src_updatebit*/1,   /*des_updatebit*/47,      /*initvalue*/0         },
           {   /*sig_name*/"isSaveSetgToMemPrmnt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/80,   /*des_id*/0x360, /*src_updatebit*/72,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerEmergCtrlSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/353,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x169, /*src_updatebit*/352,   /*des_updatebit*/45,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgPen_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/494,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/170,   /*des_id*/0x463, /*src_updatebit*/120,   /*des_updatebit*/51,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgSteerMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/503,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/170,   /*des_id*/0x463, /*src_updatebit*/120,   /*des_updatebit*/51,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgSteerAsscLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/490,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/170,   /*des_id*/0x463, /*src_updatebit*/120,   /*des_updatebit*/51,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptmtAirTEstimdExtdComptmtT_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/80,   /*des_id*/0x360, /*src_updatebit*/90,   /*des_updatebit*/42,      /*initvalue*/600         },
           {   /*sig_name*/"isCmptmtAirTEstimdExtdQlyFlg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/80,   /*des_id*/0x360, /*src_updatebit*/90,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isSecDcDcActvd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/194,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/15,   /*des_id*/0x65, /*src_updatebit*/316,   /*des_updatebit*/21,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "ZCU_CANFD1",
       /*networktype*/ "CANFD",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "ZCUD_CANFD3",
       /*networktype*/ "CANFD",
       6,
       {
           {   /*sig_name*/"isSteerEmergCtrlSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/353,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x153, /*src_updatebit*/352,   /*des_updatebit*/126,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgPen_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/494,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x153, /*src_updatebit*/120,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgSteerMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/503,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x153, /*src_updatebit*/120,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSetgSteerAsscLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/490,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x153, /*src_updatebit*/120,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerRatModReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/509,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x153, /*src_updatebit*/504,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isIAMSMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/218,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x239, /*src_updatebit*/217,   /*des_updatebit*/120,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "ChassisCANFD2",
       /*networktype*/ "CANFD",
       51,
       {
           {   /*sig_name*/"isFltTSecDcDc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/179,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0xe5, /*src_updatebit*/307,   /*des_updatebit*/446,      /*initvalue*/0         },
           {   /*sig_name*/"isUSecDcDcActHiSide_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/287,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0xdf, /*src_updatebit*/317,   /*des_updatebit*/194,      /*initvalue*/0         },
           {   /*sig_name*/"isSiteOfcommCharn_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/436,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x55,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/435,   /*des_updatebit*/242,      /*initvalue*/0         },
           {   /*sig_name*/"isLocalBookChrgnTarVal_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x35c, /*src_updatebit*/138,   /*des_updatebit*/321,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBattU_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/152,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x2a4, /*src_updatebit*/153,   /*des_updatebit*/158,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRControlPoint_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRMessageType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/5         },
           {   /*sig_name*/"isHznProfLongLRRetransmission_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLROffset_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRCyclicCounter_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRUpdate_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRValue_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/32,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRPathIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isHznProfLongLRProfileType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/139,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isPwrCnsForHvacFanFrnt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/92,   /*des_updatebit*/419,      /*initvalue*/0         },
           {   /*sig_name*/"isSocInFoOfCommChargn_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/411,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x55,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/408,   /*des_updatebit*/394,      /*initvalue*/0         },
           {   /*sig_name*/"isTelmBookChrgnTyp_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x350,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x35c, /*src_updatebit*/52,   /*des_updatebit*/316,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenSplyReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/75,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x2d2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/73,   /*des_updatebit*/179,      /*initvalue*/0         },
           {   /*sig_name*/"isTankFlapLockSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/154,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0xdf, /*src_updatebit*/153,   /*des_updatebit*/64,      /*initvalue*/0         },
           {   /*sig_name*/"isSecCnvnReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0xdf, /*src_updatebit*/196,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isSTDcDc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/343,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/264,   /*des_updatebit*/221,      /*initvalue*/40         },
           {   /*sig_name*/"isSTDcDcCoolt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/351,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/323,   /*des_updatebit*/220,      /*initvalue*/40         },
           {   /*sig_name*/"isHvacFanSts3HvacFanSpdFd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/295,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/244,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isPwrCnsForHvacFanRe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/90,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/91,   /*des_updatebit*/444,      /*initvalue*/0         },
           {   /*sig_name*/"isFltElecSecDcDc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/152,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0xe5, /*src_updatebit*/306,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isChrgnUReqSecCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/85,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/81,   /*des_updatebit*/491,      /*initvalue*/0         },
           {   /*sig_name*/"isChrgnUReqSecChrgnUReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/77,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/81,   /*des_updatebit*/491,      /*initvalue*/0         },
           {   /*sig_name*/"isChrgnUReqSecChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/69,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/81,   /*des_updatebit*/491,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRPositionConfidence_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRMessageType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/114,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/1         },
           {   /*sig_name*/"isHznPosnLRCurrentLane_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/117,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRSpeed_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRPathIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/96,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLROffset_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRCyclicCounter_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/124,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRPositionIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/122,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRPositionAge_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRRelativeHeading_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/88,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isHznPosnLRPositionProbability_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/106,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/120,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isSDcDcCoolgReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/327,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/324,   /*des_updatebit*/252,      /*initvalue*/0         },
           {   /*sig_name*/"isSuspHeiLvlSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x4f, /*src_updatebit*/25,   /*des_updatebit*/144,      /*initvalue*/3         },
           {   /*sig_name*/"isShowTypOfDTESet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/141,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x23d, /*src_updatebit*/137,   /*des_updatebit*/421,      /*initvalue*/0         },
           {   /*sig_name*/"isTelmStrtEngForChrgnReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/410,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x63,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/408,   /*des_updatebit*/64,      /*initvalue*/0         },
           {   /*sig_name*/"isISecDcDcActHiSide_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0xe5, /*src_updatebit*/308,   /*des_updatebit*/448,      /*initvalue*/4100         },
           {   /*sig_name*/"isReHvacBlowerSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/72,   /*des_updatebit*/242,      /*initvalue*/0         },
           {   /*sig_name*/"isDstFromDestination_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/346,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x42,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x86, /*src_updatebit*/352,   /*des_updatebit*/221,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnHvBattUsgModReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/194,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x140,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x86, /*src_updatebit*/88,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSocOfCommChargn_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/434,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x55,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/433,   /*des_updatebit*/395,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnHvBattUsgOfChrgTarSOC_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/367,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x42,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x4f, /*src_updatebit*/373,   /*des_updatebit*/425,      /*initvalue*/1000         },
           {   /*sig_name*/"isSDcDcMinCooltFlow_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/335,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x16f, /*src_updatebit*/328,   /*des_updatebit*/256,      /*initvalue*/20         },
           {   /*sig_name*/"isOutlSovActvSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x13c, /*src_updatebit*/80,   /*des_updatebit*/90,      /*initvalue*/1         }
       }
   },
   {
       /*des_can*/ "ZCUD_CAN1",
       /*networktype*/ "CAN",
       120,
       {
           {   /*sig_name*/"isTrlrLampChkAutReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/251,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x206, /*src_updatebit*/250,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentnForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/471,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/468,   /*des_updatebit*/17,      /*initvalue*/7         },
           {   /*sig_name*/"isTopPercTrFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/367,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/6,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x118, /*src_updatebit*/360,   /*des_updatebit*/7,      /*initvalue*/101         },
           {   /*sig_name*/"isSeatVentnRowSecLeEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/373,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/372,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRiSeatMassDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/187,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/186,   /*des_updatebit*/44,      /*initvalue*/0         },
           {   /*sig_name*/"isPassSeatUnfoldSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/211,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x121, /*src_updatebit*/168,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentAutStrtRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/450,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/449,   /*des_updatebit*/46,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatHeatgPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/271,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/40,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isPassStuMonSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/511,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/135,   /*des_id*/0x325, /*src_updatebit*/507,   /*des_updatebit*/27,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSeatSideSpprtSetg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/258,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/256,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSeatAdpvLumSetg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/511,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/510,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatDispMassgFctMassgInten_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/204,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/200,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatDispMassgFctMassgProg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/200,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatDispMassgFctOnOffl2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/202,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/200,   /*des_updatebit*/48,      /*initvalue*/2         },
           {   /*sig_name*/"isEmgyAsscTrigSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/287,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x110,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x181, /*src_updatebit*/285,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentnForRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/235,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/232,   /*des_updatebit*/24,      /*initvalue*/7         },
           {   /*sig_name*/"isSecRowLeSeatMotPosnCalReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/55,   /*des_id*/0x196, /*src_updatebit*/48,   /*des_updatebit*/35,      /*initvalue*/0         },
           {   /*sig_name*/"isHvacAirMFlowReEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/140,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x366, /*src_updatebit*/146,   /*des_updatebit*/18,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrStuMonSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/262,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/120,   /*des_id*/0x264, /*src_updatebit*/258,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdLeSeatSideSpprtDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/190,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isPwrSldgDoorLePosnReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x51, /*src_updatebit*/128,   /*des_updatebit*/24,      /*initvalue*/101         },
           {   /*sig_name*/"isSeatVentnRowThrdLeEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/371,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/370,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenSplyReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/75,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x2d2,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/73,   /*des_updatebit*/9,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatRowSecLeEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/481,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x214, /*src_updatebit*/480,   /*des_updatebit*/43,      /*initvalue*/0         },
           {   /*sig_name*/"isPosnBriefPosnLat_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/30,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_cyc*/25,   /*des_id*/0x143, /*src_updatebit*/82,   /*des_updatebit*/6,      /*initvalue*/90         },
           {   /*sig_name*/"isPosnBriefPosnLgt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/31,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_cyc*/25,   /*des_id*/0x143, /*src_updatebit*/82,   /*des_updatebit*/6,      /*initvalue*/180         },
           {   /*sig_name*/"isThrdLeSeatMassDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/162,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/161,   /*des_updatebit*/34,      /*initvalue*/0         },
           {   /*sig_name*/"isRMLCmftFctReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_cyc*/420,   /*des_id*/0x351, /*src_updatebit*/3,   /*des_updatebit*/3,      /*initvalue*/0         },
           {   /*sig_name*/"isWirelschrgActvReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x330,   /*src_dlc*/64,   /*des_cyc*/175,   /*des_id*/0x310, /*src_updatebit*/48,   /*des_updatebit*/6,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgOpenHmiReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/154,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x140,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x54, /*src_updatebit*/152,   /*des_updatebit*/7,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatAutStrtRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/409,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/408,   /*des_updatebit*/38,      /*initvalue*/0         },
           {   /*sig_name*/"isTwbrRelsReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/247,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x206, /*src_updatebit*/245,   /*des_updatebit*/46,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnRowSecRiEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/489,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x214, /*src_updatebit*/488,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRiSeatSideSpprtDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/184,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatgForRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/231,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/228,   /*des_updatebit*/9,      /*initvalue*/7         },
           {   /*sig_name*/"isChdLockPassReSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x314, /*src_updatebit*/5,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowSecPasSideSnsSts2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/76,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x78, /*src_updatebit*/74,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isPwrSldgDoorRiPosnReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x51, /*src_updatebit*/32,   /*des_updatebit*/32,      /*initvalue*/101         },
           {   /*sig_name*/"isUpperLowerTrSelnSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/425,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/424,   /*des_updatebit*/0,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassRealLockSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/309,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x337,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x76, /*src_updatebit*/307,   /*des_updatebit*/53,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiSeatVentnPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/303,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x127, /*src_updatebit*/256,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatRowSecRiEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/495,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x214, /*src_updatebit*/494,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReqForPassAirbIndcnAckd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/487,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x366, /*src_updatebit*/486,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentAutStrtRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/442,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/441,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatMotPosnCalReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/249,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/248,   /*des_updatebit*/27,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatAutStrtRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/394,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/393,   /*des_updatebit*/24,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatHeatgPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/255,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/8,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/244,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/242,   /*des_updatebit*/26,      /*initvalue*/0         },
           {   /*sig_name*/"isWPRLActvReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/18,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiHeatgLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/250,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/120,   /*des_id*/0x264, /*src_updatebit*/248,   /*des_updatebit*/61,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSeatAdpvSideSpprtSetg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/499,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/497,   /*des_updatebit*/43,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentnForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/467,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/464,   /*des_updatebit*/16,      /*initvalue*/7         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/236,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/234,   /*des_updatebit*/18,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenSplyPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/306,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x235, /*src_updatebit*/307,   /*des_updatebit*/27,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRiSeatLumDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/189,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/188,   /*des_updatebit*/46,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatDispMassgFctMassgInten_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/208,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatDispMassgFctOnOffl2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/210,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/208,   /*des_updatebit*/56,      /*initvalue*/2         },
           {   /*sig_name*/"isThrdRowRiSeatDispMassgFctMassgProg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/215,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/85,   /*des_id*/0x32f, /*src_updatebit*/208,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiSeatHeatgPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/295,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x127, /*src_updatebit*/208,   /*des_updatebit*/62,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentnForRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/236,   /*des_updatebit*/25,      /*initvalue*/7         },
           {   /*sig_name*/"isSftyAirbRollovrSuppSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/415,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x99, /*src_updatebit*/413,   /*des_updatebit*/17,      /*initvalue*/0         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosFrntHeiPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1000         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosHeiPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/173,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1000         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosSldQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/197,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosFrntHeiQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosSldPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/179,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1000         },
           {   /*sig_name*/"isPassSeatPosPercSeatPosHeiQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x398, /*src_updatebit*/195,   /*des_updatebit*/2,      /*initvalue*/1         },
           {   /*sig_name*/"isThrdLeSeatLumDisSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/164,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/163,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatgForRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/227,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/224,   /*des_updatebit*/8,      /*initvalue*/7         },
           {   /*sig_name*/"isDoorPassReRealLockSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/306,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x337,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x76, /*src_updatebit*/304,   /*des_updatebit*/50,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowLeSeatHeatgPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x2d2,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/72,   /*des_updatebit*/62,      /*initvalue*/100         },
           {   /*sig_name*/"isChgFilElmRst_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/64,   /*des_cyc*/120,   /*des_id*/0x264, /*src_updatebit*/61,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbNotiConfirm_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/407,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x99, /*src_updatebit*/405,   /*des_updatebit*/20,      /*initvalue*/0         },
           {   /*sig_name*/"isRadioFrqAM_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/396,   /*des_updatebit*/12,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbTEstimdAmbTEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/128,   /*des_updatebit*/5,      /*initvalue*/700         },
           {   /*sig_name*/"isAmbTEstimdQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/128,   /*des_updatebit*/5,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatgForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/459,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/456,   /*des_updatebit*/0,      /*initvalue*/7         },
           {   /*sig_name*/"isSecRowSeatRiChildLockSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/482,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/481,   /*des_updatebit*/49,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/217,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/227,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowFirstLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/231,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowFirstRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/221,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/225,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowFirstRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/229,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/219,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowFirstLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x490, /*src_updatebit*/16,   /*des_updatebit*/63,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatMotPosnCalReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/225,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/224,   /*des_updatebit*/26,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentAutStrtRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/202,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/201,   /*des_updatebit*/2,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/247,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/245,   /*des_updatebit*/29,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowSeatLeChildLockSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/484,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/483,   /*des_updatebit*/51,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatAutStrtRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/193,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/192,   /*des_updatebit*/34,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptmtTReCmptmtTFrntQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/41,   /*des_updatebit*/17,      /*initvalue*/1         },
           {   /*sig_name*/"isCmptmtTReCmptmtTFrnt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/41,   /*des_updatebit*/17,      /*initvalue*/600         },
           {   /*sig_name*/"isCmptmtTReFanForCmptmtTRunng_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/41,   /*des_updatebit*/17,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatVentnPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/279,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/232,   /*des_updatebit*/53,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrLampChkReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/236,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0xe0, /*src_updatebit*/234,   /*des_updatebit*/61,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatRowThrdLeEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/353,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/352,   /*des_updatebit*/62,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatLeChildLockSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/503,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/502,   /*des_updatebit*/62,      /*initvalue*/0         },
           {   /*sig_name*/"isHvacAirMFlowEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x366, /*src_updatebit*/141,   /*des_updatebit*/13,      /*initvalue*/0         },
           {   /*sig_name*/"isPassLockContnSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/281,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x76, /*src_updatebit*/280,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/237,   /*des_updatebit*/21,      /*initvalue*/0         },
           {   /*sig_name*/"isWPRRActvReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1af, /*src_updatebit*/20,   /*des_updatebit*/54,      /*initvalue*/0         },
           {   /*sig_name*/"isRMRCmftFctReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_cyc*/420,   /*des_id*/0x351, /*src_updatebit*/1,   /*des_updatebit*/1,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiSeatMotPosnCalReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/89,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/55,   /*des_id*/0x196, /*src_updatebit*/88,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiVentnLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/308,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_cyc*/120,   /*des_id*/0x264, /*src_updatebit*/306,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isTopPosTrFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/387,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x42,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0xe0, /*src_updatebit*/384,   /*des_updatebit*/15,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnRowThrdRiEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/369,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/368,   /*des_updatebit*/6,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatVentAutStrtRowThrdRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/210,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/209,   /*des_updatebit*/0,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatRowThrdRiEna_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x271, /*src_updatebit*/374,   /*des_updatebit*/60,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptmtOxygenConcVluFrmClima_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/271,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/800,   /*des_id*/0x471, /*src_updatebit*/277,   /*des_updatebit*/13,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatgForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/463,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x320,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x228, /*src_updatebit*/460,   /*des_updatebit*/1,      /*initvalue*/7         },
           {   /*sig_name*/"isBattFltStsSecBattFltStsPrm_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x99, /*src_updatebit*/176,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isBattFltStsSecChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x99, /*src_updatebit*/176,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isBattFltStsSecCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/70,   /*des_id*/0x99, /*src_updatebit*/176,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowLeSeatVentnPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x2d2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x127, /*src_updatebit*/113,   /*des_updatebit*/61,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiSeatHeatAutStrtRowThrdLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x209, /*src_updatebit*/184,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatRiChildLockSet_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/501,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/500,   /*des_updatebit*/60,      /*initvalue*/0         },
           {   /*sig_name*/"isPassSeatFoldSwt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/170,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x121, /*src_updatebit*/169,   /*des_updatebit*/20,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatVentnPwrAllwd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/263,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x215, /*src_updatebit*/41,   /*des_updatebit*/55,      /*initvalue*/0         },
           {   /*sig_name*/"isTrOpenPosnReqFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x118, /*src_updatebit*/368,   /*des_updatebit*/15,      /*initvalue*/101         }
       }
   },
   {
       /*des_can*/ "ZCUD_CANFD4",
       /*networktype*/ "CANFD",
       28,
       {
           {   /*sig_name*/"isDoorPassPosnToObst2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/290,   /*des_updatebit*/107,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassPosnToObst2AngleDeg11_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/290,   /*des_updatebit*/107,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassPosnToObst2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/290,   /*des_updatebit*/107,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassRePosnToObst2AngleDeg11_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/303,   /*des_updatebit*/171,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassRePosnToObst2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/303,   /*des_updatebit*/171,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassRePosnToObst2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/303,   /*des_updatebit*/171,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassRePosn2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/302,   /*des_updatebit*/176,      /*initvalue*/100         },
           {   /*sig_name*/"isDoorPassAntiPnch2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x100, /*src_updatebit*/273,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassPosn2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x100, /*src_updatebit*/289,   /*des_updatebit*/112,      /*initvalue*/100         },
           {   /*sig_name*/"isObstStrDetcnPassRe2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/177,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x100, /*src_updatebit*/311,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassReAntiPnch2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/296,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isHmiFanLvlRow1_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/215,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2c0, /*src_updatebit*/211,   /*des_updatebit*/11,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorLeRePercSetFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/367,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c0, /*src_updatebit*/360,   /*des_updatebit*/80,      /*initvalue*/100         },
           {   /*sig_name*/"isDoorDrvrPercSetFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x1c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c0, /*src_updatebit*/0,   /*des_updatebit*/72,      /*initvalue*/100         },
           {   /*sig_name*/"isRadioFrqAM_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c0, /*src_updatebit*/396,   /*des_updatebit*/26,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassReObstPos2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/107,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/300,   /*des_updatebit*/147,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassReObstPos2ObjectPosZ_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/300,   /*des_updatebit*/147,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassReObstPos2ObjectPosY_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/123,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/300,   /*des_updatebit*/147,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassReObstPos2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/139,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/300,   /*des_updatebit*/147,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassReObstPos2ObjectPosX_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/115,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/300,   /*des_updatebit*/147,      /*initvalue*/255         },
           {   /*sig_name*/"isObstStrDetcnPass2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/178,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x100, /*src_updatebit*/310,   /*des_updatebit*/105,      /*initvalue*/0         },
           {   /*sig_name*/"isHvacRecircAct_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x100, /*src_updatebit*/216,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassObstPos2ObjectPosZ_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/288,   /*des_updatebit*/83,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassObstPos2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/288,   /*des_updatebit*/83,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassObstPos2ObjectPosY_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/288,   /*des_updatebit*/83,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorPassObstPos2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/288,   /*des_updatebit*/83,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorPassObstPos2ObjectPosX_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x50, /*src_updatebit*/288,   /*des_updatebit*/83,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorRiRePercSetFromHmi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x1c1,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c0, /*src_updatebit*/376,   /*des_updatebit*/88,      /*initvalue*/100         }
       }
   },
   {
       /*des_can*/ "ZCU_CANFD2",
       /*networktype*/ "CANFD",
       3050,
       {
           {   /*sig_name*/"isADL3LatCtrlStsQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsCtrlSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsDegraded_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsADMod_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isADL3LatCtrlStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/23,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isRBUMonitorSignals_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/64,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/113,   /*des_updatebit*/183,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isFrSunCurtImpctDetSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/92,      /*initvalue*/0         },
           {   /*sig_name*/"isCrashUnlckActvn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x10a,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/6,   /*des_updatebit*/478,      /*initvalue*/0         },
           {   /*sig_name*/"isTrOpenerByFootOperSts_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/22,   /*src_dlc*/1,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/1000,   /*des_updatebit*/474,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapFltSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x2fa,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/9,   /*des_updatebit*/421,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapBuckSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x2fa,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/4,   /*des_updatebit*/200,      /*initvalue*/0         },
           {   /*sig_name*/"isInpVoltFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x2d0,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/24,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdLeInclAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/50,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isSWVLMotrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/56,   /*des_updatebit*/489,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatHeatgActlPwrCnsRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x336,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/15,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenConcFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/37,   /*des_updatebit*/258,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiVentnAutoSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/28,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isStepLVLMotrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/60,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnAvlStsRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x329,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/0,   /*des_updatebit*/428,      /*initvalue*/0         },
           {   /*sig_name*/"isBattCycDchaCntrDurgDrvgRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/193,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1MaxRackPosnLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/73,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1RackMtrTrq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/18,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/130000         },
           {   /*sig_name*/"isPubCANRWA1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/122,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/109,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1RackFEstimdVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/132,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1AgCtrlPath_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/126,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1ActRackPosn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/15000         },
           {   /*sig_name*/"isPubCANRWA1Group1TarRackPosnAtADAS_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/15000         },
           {   /*sig_name*/"isPubCANRWA1Group1ActRackPosnQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/134,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/1         },
           {   /*sig_name*/"isPubCANRWA1Group1ActRackPosnVel_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/5000         },
           {   /*sig_name*/"isPubCANRWA1Group1MaxRackPosnRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/91,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1RackMtrTrqVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1PwrCpFac_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/117,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWA1Group1RackFEstimd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/130,   /*des_updatebit*/226,      /*initvalue*/25000         },
           {   /*sig_name*/"isCH10DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/48,   /*des_updatebit*/107,      /*initvalue*/0         },
           {   /*sig_name*/"isCoolgFanErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/27,   /*des_updatebit*/154,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRDRMVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Chk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockChk2Data1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/62,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerErrReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/52,   /*des_updatebit*/462,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatVentnActlPwrCnsRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x336,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/13,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh4Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/178,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapU5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x1fa,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/43,   /*des_updatebit*/113,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatHeatgDesPwrCnsLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/26,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isTrOpenerSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/4,   /*des_updatebit*/83,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptmtCoolgSts_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x31d,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/4,   /*des_updatebit*/403,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCThirdRowBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/240,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCThirdRowBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/240,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapSoh_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x2fa,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/37,   /*des_updatebit*/445,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqTotDrgAtWhls_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/255,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh3Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/1,   /*des_updatebit*/170,      /*initvalue*/0         },
           {   /*sig_name*/"isADC1DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/0,   /*des_updatebit*/320,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCFrBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/235,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCFrBtnErrStsIntrLiSwtAutOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/235,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCFrBtnErrStsIntrLiSwtAllOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/235,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCFrBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/235,      /*initvalue*/0         },
           {   /*sig_name*/"isBattRRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/424,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReCloseReqInsdSwt_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/33,   /*des_updatebit*/184,      /*initvalue*/2         },
           {   /*sig_name*/"isRowSecRiLegRstHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/12,   /*des_updatebit*/267,      /*initvalue*/1         },
           {   /*sig_name*/"isRowSecRiLegRstHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/12,   /*des_updatebit*/267,      /*initvalue*/1000         },
           {   /*sig_name*/"isBattCpEstimdAtTNomRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/144,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHWAMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowFrthRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/28,   /*des_updatebit*/282,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrObstPos2ObjectPosX_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/443,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrObstPos2ObjectPosY_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/443,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrObstPos2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/443,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrObstPos2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/443,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrObstPos2ObjectPosZ_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/443,      /*initvalue*/255         },
           {   /*sig_name*/"isBattCircOpenU_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/138,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrPrmntPwrActv_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/21,   /*des_updatebit*/388,      /*initvalue*/1         },
           {   /*sig_name*/"isStreamingMirrImg_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/259,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapU2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x1fa,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/46,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2CurtMotHallNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtFailrSRM2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/41,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh9Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/17,   /*des_updatebit*/218,      /*initvalue*/0         },
           {   /*sig_name*/"isEboostModSts_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/11,   /*des_updatebit*/392,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh3Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/1,   /*des_updatebit*/82,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntPosnLampWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorMaxOpnSetStsDrvr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/24,   /*des_updatebit*/248,      /*initvalue*/101         },
           {   /*sig_name*/"isFctOfLeCh9Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/17,   /*des_updatebit*/130,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntTurnIndcrWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/280,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrRePosn2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/8,   /*des_updatebit*/452,      /*initvalue*/100         },
           {   /*sig_name*/"isTIRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/1,   /*des_updatebit*/337,      /*initvalue*/0         },
           {   /*sig_name*/"isTankTurnActRotAng_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/353,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/425,   /*des_updatebit*/465,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltTmrFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltActrFlt5_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltActrFlt4_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltActrFlt3_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltActrFlt2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrIntFltActrFlt1_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotHallNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndFltngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndDisSldngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/390,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndDriveOpnDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndPreConNotFulfil_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndFltAndPitchWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndStpDurngMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndEndNotSuccssWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndStrMovngWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngRiReWarnIndDurngDoorMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/461,      /*initvalue*/0         },
           {   /*sig_name*/"isADC4DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/20,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReHoldingSts_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x1d5,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/6,   /*des_updatebit*/380,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1DrvrSteerWhlHld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/136,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1SteerAstLvl_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/132,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1SteerSftyLimrSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1TarRackPosnQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/148,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/1         },
           {   /*sig_name*/"isPubCANHWA1Group1TarRackPosnVel_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/5000         },
           {   /*sig_name*/"isPubCANHWA1Group1DrvrSteerActv_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/145,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1DrvrInpFac_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/97,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1ColAgQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/142,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/1         },
           {   /*sig_name*/"isPubCANHWA1Group1AlignmentSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/146,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1HwaSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/89,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1ColTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/7680         },
           {   /*sig_name*/"isPubCANHWA1Group1PwrCpVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/144,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1ColAg_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/16384         },
           {   /*sig_name*/"isPubCANHWA1Group1TankTurnSteerWhlCfm_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/129,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1TarRackPosn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/15000         },
           {   /*sig_name*/"isPubCANHWA1Group1ActrCtrlSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/115,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1DrvrTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/7680         },
           {   /*sig_name*/"isPubCANHWA1Group1ColTqQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/140,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/1         },
           {   /*sig_name*/"isPubCANHWA1Group1ADASLvlCfmd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1ColAgSpd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/6400         },
           {   /*sig_name*/"isPubCANHWA1Group1SteerStsToCrabMov_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/150,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1DrvrSteerWhlHldQly_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/123,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1PwrCp_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/106,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWA1Group1ColTqVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/138,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/158,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprInPrkgPosnLoFromWMM_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isSecDcDcActvdReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/67,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/66,   /*des_updatebit*/181,      /*initvalue*/0         },
           {   /*sig_name*/"isHoodObstclDetn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/4,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isSupply5VErrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x25f,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/15,   /*des_updatebit*/485,      /*initvalue*/0         },
           {   /*sig_name*/"isRWA2SysStsR2MaiSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x177,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/15,   /*des_updatebit*/111,      /*initvalue*/0         },
           {   /*sig_name*/"isRWA2SysStsR2FctModCfmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x177,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/15,   /*des_updatebit*/111,      /*initvalue*/0         },
           {   /*sig_name*/"isDRLRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/49,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCRwsAngReqForTvcChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/28,   /*des_updatebit*/164,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCRwsAngReqForTvcCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/28,   /*des_updatebit*/164,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCRwsAngReqForTvcTVCRwsAngReqForTvc_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/28,   /*des_updatebit*/164,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeMassgLimtStsFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/11,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeas_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmModNotAvlSts2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x80,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/48,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmGearActrScanForRefActv_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x13a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/310,      /*initvalue*/0         },
           {   /*sig_name*/"isMatrixADCErrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/32,   /*des_updatebit*/451,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatRowThrdLeMassgRunng_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x341,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/60,   /*des_updatebit*/454,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone5_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone6_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone3_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone1_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiIntensityValZone4_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isWrmUpCyc_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/102,   /*des_updatebit*/366,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSRadrTreq2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/168,      /*initvalue*/250         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid18_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid53_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid40_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid42_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid48_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid43_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid15_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid20_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid27_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid32_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid51_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid38_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid58_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid55_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid10_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid49_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid12_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid47_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid54_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid61_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid25_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid29_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid19_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid37_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid21_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid22_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid45_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid52_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid30_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid23_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid57_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid60_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid39_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid31_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid34_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid35_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid36_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid9_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid59_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid44_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid8_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid28_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid13_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid41_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid14_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid17_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid50_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid16_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid46_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMBlockID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid11_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid33_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid26_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid24_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorRBCMVFCid56_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isEngCrashFb_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/5,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatVentnDesPwrCnsRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x336,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/12,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isHCMR2DTCGroup1_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/130,      /*initvalue*/0         },
           {   /*sig_name*/"isPtBrkTqReqToFriChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/72,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/498,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isPtBrkTqReqToFriQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/498,   /*des_updatebit*/434,      /*initvalue*/3         },
           {   /*sig_name*/"isPtBrkTqReqToFriPtBrkTqRgnAtAxleReAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/498,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isPtBrkTqReqToFriCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/80,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/498,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isLMMLedDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/40,   /*des_updatebit*/162,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFltStsForEcuDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/314,      /*initvalue*/0         },
           {   /*sig_name*/"isEngCooltLvl_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/65,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/64,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgIDc_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/377,      /*initvalue*/8190         },
           {   /*sig_name*/"isDtEngdStDtEngdRe_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/166,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/208,   /*des_updatebit*/99,      /*initvalue*/0         },
           {   /*sig_name*/"isDtEngdStDtEngdFrnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/208,   /*des_updatebit*/99,      /*initvalue*/0         },
           {   /*sig_name*/"isDtEngdStDtNotEngdRe_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/164,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/208,   /*des_updatebit*/99,      /*initvalue*/0         },
           {   /*sig_name*/"isDtEngdStDtNotEngdFrnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/165,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/208,   /*des_updatebit*/99,      /*initvalue*/0         },
           {   /*sig_name*/"isRWA2EgyCnsGroupIVal_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/26,   /*des_updatebit*/282,      /*initvalue*/2500         },
           {   /*sig_name*/"isRWA2EgyCnsGroupUval_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/26,   /*des_updatebit*/282,      /*initvalue*/0         },
           {   /*sig_name*/"isWPRRPhoneForgottenRmn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x217,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1,   /*des_updatebit*/448,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/499,   /*des_updatebit*/456,      /*initvalue*/0         },
           {   /*sig_name*/"isMatrixADCErrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/32,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowSeatVentnActlPwrCnsRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/25,   /*des_updatebit*/474,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHSWTRawThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x151,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/136,      /*initvalue*/900         },
           {   /*sig_name*/"isSeatVentnLvlStsRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x341,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/50,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isSecLeVentnHeatgWarnSMX_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/43,   /*des_updatebit*/341,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbIllmnFwdStsCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbIllmnFwdStsAmblillmn1_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbIllmnFwdStsAmblillmn2_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isAmbIllmnFwdStsChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngLeReStsDoorOpenSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/32,   /*des_updatebit*/490,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngLeReStsFrstTmLveAbnd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/32,   /*des_updatebit*/490,      /*initvalue*/0         },
           {   /*sig_name*/"isWshngCycActvFromWMM_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/502,      /*initvalue*/0         },
           {   /*sig_name*/"isLogoRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/10,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isParkByDrvrWhlsFrntSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/395,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isParkByDrvrWhlsFrntSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/395,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isParkByDrvrWhlsFrntSafeSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/387,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/395,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isTrCinhSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x242,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/53,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isTrInsdOpenSwtSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/50,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isStepLVLMotrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/60,   /*des_updatebit*/476,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlSnsrChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/7,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlSnsrQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/7,   /*des_updatebit*/464,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlSnsrAgSpd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/7,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlSnsrCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/7,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlSnsrAg_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/7,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapIntR_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x2fa,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/8,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCPrpsnTqDistActv_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/24,   /*des_updatebit*/129,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprMotErrSafe_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/477,      /*initvalue*/1         },
           {   /*sig_name*/"isSeatMassgFctCptFailrRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x79,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/6,   /*des_updatebit*/318,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrSecOpnSts_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x1d0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/4,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isWhlMotSysRiSpdActSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/129,   /*des_updatebit*/406,      /*initvalue*/0         },
           {   /*sig_name*/"isWhlMotSysRiSpdActSafeIsgSpdActSgn800_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/129,   /*des_updatebit*/406,      /*initvalue*/20000         },
           {   /*sig_name*/"isWhlMotSysRiSpdActSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/129,   /*des_updatebit*/406,      /*initvalue*/1         },
           {   /*sig_name*/"isWhlMotSysRiSpdActSafeQF_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/129,   /*des_updatebit*/406,      /*initvalue*/1         },
           {   /*sig_name*/"isAdjSpdLimnActvnOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/305,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/304,   /*des_updatebit*/488,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapTemp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x2fa,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/36,   /*des_updatebit*/216,      /*initvalue*/43         },
           {   /*sig_name*/"isMotTempSnsrErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/38,   /*des_updatebit*/261,      /*initvalue*/0         },
           {   /*sig_name*/"isInternalErrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/42,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isStreamingMirrEnable_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/330,      /*initvalue*/1         },
           {   /*sig_name*/"isLRDetctDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x25f,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/2,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowThrdRiFldRsdTrnkSwtSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x207,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/25,   /*des_updatebit*/280,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfWelGbyFrntWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/470,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh8Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/18,   /*des_updatebit*/122,      /*initvalue*/0         },
           {   /*sig_name*/"isMotTempFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x2d0,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/58,   /*des_updatebit*/218,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMRunTi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/32,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/16,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isSupplyInptDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x25e,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/12,   /*des_updatebit*/482,      /*initvalue*/0         },
           {   /*sig_name*/"isMcuTempFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x2d0,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/42,   /*des_updatebit*/186,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrElecRunngBdSts_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqR2Chks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqR2SteerErrReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqR2Cntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isRowReLeInclAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/42,   /*des_updatebit*/1,      /*initvalue*/0         },
           {   /*sig_name*/"isCANCommErrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/26,   /*des_updatebit*/113,      /*initvalue*/0         },
           {   /*sig_name*/"isRestrntSysMsgReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/49,   /*des_updatebit*/445,      /*initvalue*/1         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockChkSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimWakeupActvFlg_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimHiTFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimUvCellFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimOvCellFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimResetActFlg_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimOcFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimRlyOpenSoonIndcn_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
