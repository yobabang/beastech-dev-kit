           {   /*sig_name*/"isCalStsToDHU_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/493,      /*initvalue*/0         },
           {   /*sig_name*/"isHwSwtRowSecLeEasyInOutForThrd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x21a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/48,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHRMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x574,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isHiLoBeamRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/24,   /*des_updatebit*/288,      /*initvalue*/0         },
           {   /*sig_name*/"isADSLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/42,   /*des_updatebit*/2,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh7Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isKnkSnsrFltSts_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/12,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/472,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgLimnIndcn_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/376,   /*des_updatebit*/24,      /*initvalue*/0         },
           {   /*sig_name*/"isTcsConTCtrlSts_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/2         },
           {   /*sig_name*/"isPtnDimRoofFailrStsECUFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsOutOverCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsIntLowVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsLoadErr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsOutOpenCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsIntHighVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isPtnDimRoofFailrStsResvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrPercPosn2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x1d0,   /*src_dlc*/64,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/8,   /*des_updatebit*/16,      /*initvalue*/101         },
           {   /*sig_name*/"isPedProtnMsgReqForImpct_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/442,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/52,   /*des_updatebit*/441,      /*initvalue*/0         },
           {   /*sig_name*/"isElecChromRoofFb_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/227,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSteerActvCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/10,   /*des_updatebit*/298,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSteerActvDrvrSteerActv_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/10,   /*des_updatebit*/298,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSteerActvChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/10,   /*des_updatebit*/298,      /*initvalue*/0         },
           {   /*sig_name*/"isBattCycDchaCntrDurgConvceRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/177,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrlMirrDispSysSts_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/288,      /*initvalue*/0         },
           {   /*sig_name*/"isWadeProtnSts_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x131,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/9,   /*des_updatebit*/193,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh5Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/10,   /*des_updatebit*/98,      /*initvalue*/0         },
           {   /*sig_name*/"isBattChrgnBalDurgDrvgRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/33,      /*initvalue*/20000         },
           {   /*sig_name*/"isDoorDrvrPosnToObst2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/449,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrPosnToObst2AngleDeg11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/449,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrPosnToObst2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/449,      /*initvalue*/255         },
           {   /*sig_name*/"isSunCurtMvngSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/328,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntPosnLampWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/264,      /*initvalue*/0         },
           {   /*sig_name*/"isCH7DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/60,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataFData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/39,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2PanMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2PanMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtFailr2PanMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrPosnLiSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/13,   /*des_updatebit*/390,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReRiDmcSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/86,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReRiChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/86,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReRiCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/86,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReRiDmcSWInfo_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/86,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReRiDmcActAppTarTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/86,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerServoSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/55,   /*des_updatebit*/463,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrReDoorSpindleMotorFault_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x1d5,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/11,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isHvSysRlyStsChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/9,   /*des_updatebit*/345,      /*initvalue*/0         },
           {   /*sig_name*/"isHvSysRlyStsCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/9,   /*des_updatebit*/345,      /*initvalue*/0         },
           {   /*sig_name*/"isHvSysRlyStsHvSysRlySts_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x161,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/9,   /*des_updatebit*/345,      /*initvalue*/2         },
           {   /*sig_name*/"isMonrCycCmpl_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/377,   /*des_updatebit*/398,      /*initvalue*/0         },
           {   /*sig_name*/"isSemiElecTwbrPosn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x159,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/1,   /*des_updatebit*/208,      /*initvalue*/0         },
           {   /*sig_name*/"isMosTempSnsrErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/39,   /*des_updatebit*/250,      /*initvalue*/0         },
           {   /*sig_name*/"isLatCtrlModCfmdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/23,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isLatCtrlModCfmdLatCtrlMod_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/23,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isLatCtrlModCfmdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/23,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isADC5DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/16,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsH1FltStsH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/27,   /*des_updatebit*/347,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsH1FltStsH2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/27,   /*des_updatebit*/347,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsH1FltStsR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/27,   /*des_updatebit*/347,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsH1FltStsR2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/27,   /*des_updatebit*/347,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgOpenerSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/43,   /*des_updatebit*/487,      /*initvalue*/0         },
           {   /*sig_name*/"isCH8DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/61,   /*des_updatebit*/267,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofPosnSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpct2ImpctDvySigned_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x148,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/21,   /*des_updatebit*/229,      /*initvalue*/255         },
           {   /*sig_name*/"isRecOfImpct2ImpctDvxSigned_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x148,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/21,   /*des_updatebit*/229,      /*initvalue*/255         },
           {   /*sig_name*/"isSteerWhlTqAddl_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/41,   /*des_updatebit*/281,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeHeatgAutoSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/23,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh11Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/9,   /*des_updatebit*/146,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrRePercPosn2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/504,      /*initvalue*/101         },
           {   /*sig_name*/"isSteerStsToParkAssi_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/48,   /*des_updatebit*/276,      /*initvalue*/0         },
           {   /*sig_name*/"isPinionSteerAgMax1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x3bb,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/55,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprMotCrkAg_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/498,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdRiFldRsdSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/42,   /*des_updatebit*/66,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorOpenerDrvrSts2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/1,   /*des_updatebit*/454,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x557,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctCptFailrRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/21,   /*des_updatebit*/316,      /*initvalue*/0         },
           {   /*sig_name*/"isADC3DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/8,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtExtrLi2LiExtFctQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/449,      /*initvalue*/1         },
           {   /*sig_name*/"isSwtExtrLi2LiExtFctCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/449,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtExtrLi2LiExtFctReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/449,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtExtrLi2LiExtFctCrc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/449,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenConcFbFrmOGM_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/20,   /*des_updatebit*/363,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdRiSldAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/51,   /*des_updatebit*/74,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerSftyLimrSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/58,   /*des_updatebit*/476,      /*initvalue*/0         },
           {   /*sig_name*/"isBattIQuiscFildShoRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/370,      /*initvalue*/511         },
           {   /*sig_name*/"isAdjSpdLimnMsg_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/370,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/368,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isVlvVoltFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/420,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/33,   /*des_updatebit*/418,      /*initvalue*/0         },
           {   /*sig_name*/"isAltFltElec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/0,   /*des_updatebit*/280,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtAData2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtACnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/7,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isFuLvlLoIndcnECM_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x171,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/38,   /*des_updatebit*/408,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnPrio_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnPfmncReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnAllwdSts1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnAllwdSts2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnModReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x138,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/16,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isTwbrRelsBtn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x159,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/2,   /*des_updatebit*/396,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdRiMassgSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/72,      /*initvalue*/0         },
           {   /*sig_name*/"isThermoTSteDeoSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/15,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/1000,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isR290LeakSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/0,   /*des_updatebit*/457,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdSeatLeCushFldLckMotSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/13,   /*des_updatebit*/377,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvgCyc_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/226,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/225,   /*des_updatebit*/455,      /*initvalue*/0         },
           {   /*sig_name*/"isCH10DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/48,   /*des_updatebit*/99,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh2Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/2,   /*des_updatebit*/74,      /*initvalue*/0         },
           {   /*sig_name*/"isAltIAvl_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/254,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/261,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRaw2SafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/6,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRaw2SafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/6,   /*des_updatebit*/25,      /*initvalue*/255         },
           {   /*sig_name*/"isAgDataRaw2SafePitchRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/6,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRaw2SafePitchRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/6,   /*des_updatebit*/25,      /*initvalue*/1         },
           {   /*sig_name*/"isWinSwtReqCntr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isWinSwtReqReLe_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isWinSwtReqReRi_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isWinSwtReqFrntRi_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isWinSwtReqChks_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isWinSwtReqFrntLe_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRawSafeYawRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRawSafeRollRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/1         },
           {   /*sig_name*/"isAgDataRawSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isAgDataRawSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/255         },
           {   /*sig_name*/"isAgDataRawSafeYawRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/1         },
           {   /*sig_name*/"isAgDataRawSafeRollRate_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x89,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/5,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isWhlMotSysRiModSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/83,   /*des_updatebit*/471,      /*initvalue*/0         },
           {   /*sig_name*/"isImobEngSts1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/68,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/700,   /*des_id*/0x40a, /*src_updatebit*/66,   /*des_updatebit*/45,      /*initvalue*/0         },
           {   /*sig_name*/"isRearSteerMotInfoGroupChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isRearSteerMotInfoGroupMotTqQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/1         },
           {   /*sig_name*/"isRearSteerMotInfoGroupMotSpdQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/1         },
           {   /*sig_name*/"isRearSteerMotInfoGroupMotSpd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isRearSteerMotInfoGroupCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isRearSteerMotInfoGroupMotTq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x61,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/56,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmDtModAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/82,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/56,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isSwivelMotRiIninSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/4,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRiVentnHeatgWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x329,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1,   /*des_updatebit*/408,      /*initvalue*/0         },
           {   /*sig_name*/"isMosOvrTempErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/24,   /*des_updatebit*/253,      /*initvalue*/0         },
           {   /*sig_name*/"isADC6DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/28,   /*des_updatebit*/360,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtMoveDir2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/50,      /*initvalue*/0         },
           {   /*sig_name*/"isAssiLiRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/41,   /*des_updatebit*/0,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedCornrgLampwithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/200,      /*initvalue*/0         },
           {   /*sig_name*/"isHWAMotTqGroupH1EstimateMotTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/75,   /*des_updatebit*/171,      /*initvalue*/0         },
           {   /*sig_name*/"isHWAMotTqGroupH1TarMotTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/75,   /*des_updatebit*/171,      /*initvalue*/0         },
           {   /*sig_name*/"isBrkLiReqRegenCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/42,   /*des_updatebit*/306,      /*initvalue*/0         },
           {   /*sig_name*/"isBrkLiReqRegenOnOff_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/42,   /*des_updatebit*/306,      /*initvalue*/0         },
           {   /*sig_name*/"isBrkLiReqRegenChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/42,   /*des_updatebit*/306,      /*initvalue*/0         },
           {   /*sig_name*/"isEPBLockSts2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/59,   /*des_updatebit*/273,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataCData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/36,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isAutoShowModPrpsnEna_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/397,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/396,   /*des_updatebit*/505,      /*initvalue*/0         },
           {   /*sig_name*/"isLevelMotLeIninSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/6,   /*des_updatebit*/145,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiZeroGrvyPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/24,   /*des_updatebit*/331,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiZeroGrvyPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/24,   /*des_updatebit*/331,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdSeatLePosCalResp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/38,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isStopReqOfLgtCtrlForPrpsn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x2a5,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/8,   /*des_updatebit*/486,      /*initvalue*/0         },
           {   /*sig_name*/"isECUVariantOfHCMR3_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/26,   /*des_updatebit*/64,      /*initvalue*/0         },
           {   /*sig_name*/"isCANCommErrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/26,   /*des_updatebit*/121,      /*initvalue*/0         },
           {   /*sig_name*/"isSplyFailrOfLeReKickSnsr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/24,   /*src_dlc*/1,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/1000,   /*des_updatebit*/489,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptFrntWindT_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/336,      /*initvalue*/650         },
           {   /*sig_name*/"isTailgCllsnRiskSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x242,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/55,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHSWTRawSecRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/3,   /*des_updatebit*/112,      /*initvalue*/900         },
           {   /*sig_name*/"isAMBStsHUDLiIllmnChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/28,      /*initvalue*/0         },
           {   /*sig_name*/"isAMBStsHUDLiIllmnCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/28,      /*initvalue*/0         },
           {   /*sig_name*/"isAMBStsHUDLiIllmnAMBStsHUDLiIllmn_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/28,      /*initvalue*/0         },
           {   /*sig_name*/"isBrkSysWarnIndcnReqSec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/28,   /*des_updatebit*/505,      /*initvalue*/0         },
           {   /*sig_name*/"isCatchActvnSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/6,   /*des_updatebit*/481,      /*initvalue*/0         },
           {   /*sig_name*/"isADC5DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/16,   /*des_updatebit*/356,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMIntErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/6,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecHostAvailabilityRelOnly_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecCommunicationAvailable_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecReserved2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbAvlSecHostAvailabilityFull_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/4,   /*des_updatebit*/217,      /*initvalue*/0         },
           {   /*sig_name*/"isDRLAndPosRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSRadrTSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/280,      /*initvalue*/250         },
           {   /*sig_name*/"isPhaseCurrentFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x2d4,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/8,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isOvrdDecelByDrvrChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/378,   /*des_updatebit*/322,      /*initvalue*/255         },
           {   /*sig_name*/"isOvrdDecelByDrvrOvrdDecelByDrvr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/379,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/378,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isOvrdDecelByDrvrCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/378,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockWarnIndcn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/300,   /*des_id*/0x371, /*src_updatebit*/13,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved10_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved0_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimACFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimRMFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved8_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimBCFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved9_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimBuckFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimReserved6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBattHwFltStsPrimMosFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlNotCmplPsdSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/242,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/241,   /*des_updatebit*/305,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlNotCmplPsdCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/247,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/241,   /*des_updatebit*/305,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlNotCmplPsdChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/241,   /*des_updatebit*/305,      /*initvalue*/255         },
           {   /*sig_name*/"isAccrPedlNotCmplPsd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/243,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/241,   /*des_updatebit*/305,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprActvFromWMM_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/488,      /*initvalue*/0         },
           {   /*sig_name*/"isECUVariantOfHCML3_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/26,   /*des_updatebit*/68,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtPosnSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/58,      /*initvalue*/0         },
           {   /*sig_name*/"isHSD1DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/40,   /*des_updatebit*/372,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenSplyAvlSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/23,   /*des_updatebit*/20,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeSeatRotPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x79,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/440,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReSecOpnSts_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x1d5,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/4,   /*des_updatebit*/378,      /*initvalue*/0         },
           {   /*sig_name*/"isHCML2DTCGroup1_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnLvlStsRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x342,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/50,   /*des_updatebit*/384,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSteerWhlHldGroupDrvrSteerWhlHldQly_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/41,   /*des_updatebit*/425,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrSteerWhlHldGroupDrvrSteerWhlHld_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/41,   /*des_updatebit*/425,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmReqForPfmncRedn3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x80,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/56,   /*des_updatebit*/490,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngDoorRiRePos_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/22,   /*des_updatebit*/80,      /*initvalue*/101         },
           {   /*sig_name*/"isAsyDataWithCmpSafeALat1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/1         },
           {   /*sig_name*/"isAsyDataWithCmpSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/255         },
           {   /*sig_name*/"isAsyDataWithCmpSafeYawRateWithCmp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/0         },
           {   /*sig_name*/"isAsyDataWithCmpSafeALatWithCmp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/0         },
           {   /*sig_name*/"isAsyDataWithCmpSafeGrdtOfALgt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/0         },
           {   /*sig_name*/"isAsyDataWithCmpSafeYawRateQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/1         },
           {   /*sig_name*/"isAsyDataWithCmpSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/0         },
           {   /*sig_name*/"isAsyDataWithCmpSafeALgt1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x13,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/56,   /*des_updatebit*/112,      /*initvalue*/1         },
           {   /*sig_name*/"isTCScoolgGrdReq2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/275,      /*initvalue*/0         },
           {   /*sig_name*/"isSoundSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/488,      /*initvalue*/0         },
           {   /*sig_name*/"isCH5DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/58,   /*des_updatebit*/219,      /*initvalue*/0         },
           {   /*sig_name*/"isLsmMaxDefrstSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/366,      /*initvalue*/0         },
           {   /*sig_name*/"isSuspStfnVlvCtrlStsFbFL_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/32,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isSuspStfnVlvCtrlStsFbRR_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/32,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isSuspStfnVlvCtrlStsFbRL_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/32,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isSuspStfnVlvCtrlStsFbFR_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x53,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/32,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeSeatHeatgBtn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/59,   /*des_updatebit*/292,      /*initvalue*/0         },
           {   /*sig_name*/"isMotStsFrmOGM_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/15,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtRowFrthMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/32,   /*des_updatebit*/228,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowFrthMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/32,   /*des_updatebit*/228,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtRowFrthMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/32,   /*des_updatebit*/228,      /*initvalue*/1         },
           {   /*sig_name*/"isDeactvtTestCom_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/192,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isStrtReqOfLgtCtrlForPrpsn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x2a5,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/16,   /*des_updatebit*/484,      /*initvalue*/0         },
           {   /*sig_name*/"isCH1DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/51,   /*des_updatebit*/155,      /*initvalue*/0         },
           {   /*sig_name*/"isCVCH2DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/51,   /*des_updatebit*/307,      /*initvalue*/0         },
           {   /*sig_name*/"isAltitudeInfrom_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/32,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isBattIQuiscFildLongRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/364,      /*initvalue*/511         },
           {   /*sig_name*/"isHWASyncStsGroupH2SyncSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/450,      /*initvalue*/0         },
           {   /*sig_name*/"isHWASyncStsGroupH2SyncOvrdIndcn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/450,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmClu0StsTrsm0CluSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/355,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/432,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmClu0StsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/351,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/432,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmClu0StsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/359,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/432,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeAvert_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/257,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1155         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeAVertQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/290,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeALat1Qf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/294,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeALgt_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/240,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafePitchRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeYawRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeRollRate_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeALat_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/274,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/255         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/282,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/0         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeYawRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/300,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isIntgtIMUDataRawSafePitchRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/288,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeALgt1Qf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/292,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isIntgtIMUDataRawSafeRollRateQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/302,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x32,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/298,   /*des_updatebit*/402,      /*initvalue*/1         },
           {   /*sig_name*/"isLiOprnMod_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowThrdRiSnsSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/61,   /*des_updatebit*/82,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowThrdLe2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/32,   /*des_updatebit*/328,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowFrthLeBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/36,   /*des_updatebit*/216,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowFrthLeBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/36,   /*des_updatebit*/216,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowFrthLeBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/36,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isRWA1EgyCnsGroupIVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/26,   /*des_updatebit*/261,      /*initvalue*/2500         },
           {   /*sig_name*/"isRWA1EgyCnsGroupUval_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/26,   /*des_updatebit*/261,      /*initvalue*/0         },
           {   /*sig_name*/"isInternalErrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/42,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCrc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/8,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/8,   /*des_updatebit*/168,      /*initvalue*/1         },
           {   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/8,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntWiprLvrCmd2FrntWiprLvrCmd1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/8,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfWelGbyFrntWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/457,      /*initvalue*/0         },
           {   /*sig_name*/"isObstStrDetcnDrvr2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/22,   /*des_updatebit*/394,      /*initvalue*/0         },
           {   /*sig_name*/"isTopPosHmiFeedBack2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x242,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/7,   /*des_updatebit*/344,      /*initvalue*/95         },
           {   /*sig_name*/"isSldngDoorLeRePos_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/22,   /*des_updatebit*/72,      /*initvalue*/101         },
           {   /*sig_name*/"isActvReSplrHallSnsrFltHallBFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/484,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrHallSnsrFltHallAFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/484,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrHallSnsrFltHallOutpFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/484,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/51,   /*des_updatebit*/251,      /*initvalue*/1         },
           {   /*sig_name*/"isRowSecLeSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/51,   /*des_updatebit*/251,      /*initvalue*/1000         },
           {   /*sig_name*/"isFloatDrivingModStsSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/307,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/376,   /*des_updatebit*/496,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrivingModStsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/303,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/376,   /*des_updatebit*/496,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrivingModStsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/311,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/376,   /*des_updatebit*/496,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataBData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/42,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isLiLvrSwt1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/59,   /*des_updatebit*/448,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowSeatHeatgActlPwrCnsRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/27,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgAvlStsRowSecRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/59,   /*des_updatebit*/412,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowThrdMid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/58,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isWPCModuleStsWPC5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x30a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/11,   /*des_updatebit*/491,      /*initvalue*/1         },
           {   /*sig_name*/"isAssiLiLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/41,   /*des_updatebit*/1,      /*initvalue*/0         },
           {   /*sig_name*/"isImobBrkNrSerlReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/201,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/200,   /*des_updatebit*/320,      /*initvalue*/0         },
           {   /*sig_name*/"isEngSt1WdSts1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/41,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isEngLoadReqElec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/224,   /*des_updatebit*/139,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActtnReq3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/22,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSTmrStrtSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/15,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrOpenPosn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x242,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/15,   /*des_updatebit*/392,      /*initvalue*/101         },
           {   /*sig_name*/"isAdjSpdLimnSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/100,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/97,   /*des_updatebit*/440,      /*initvalue*/1         },
           {   /*sig_name*/"isRainSnsrDiagcRainSnsrHiTDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/349,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsrDiagcRainSnsrHiVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/349,      /*initvalue*/0         },
           {   /*sig_name*/"isLoadValCalcd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/101,   /*des_updatebit*/457,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/229,      /*initvalue*/0         },
           {   /*sig_name*/"isHSD2DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/52,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrPosn2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/8,   /*des_updatebit*/448,      /*initvalue*/100         },
           {   /*sig_name*/"isTCSTmrOverSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/15,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/210,      /*initvalue*/0         },
           {   /*sig_name*/"isDstEstimdToEmptyForDrvgElec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/148,   /*des_updatebit*/428,      /*initvalue*/0         },
           {   /*sig_name*/"isStandStillReqForCmftToBrkgForEPedl_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/65,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/64,   /*des_updatebit*/356,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSRSVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x55b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isBrkBoostErrIndcnReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/57,   /*des_updatebit*/507,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrvingModStsForAutoMod_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0xe2,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/204,   /*des_updatebit*/108,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCSecRowBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isOHCSecRowBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isCrashSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/30,   /*des_updatebit*/133,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmSelfLrngMod_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x154,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/19,   /*des_updatebit*/499,      /*initvalue*/0         },
           {   /*sig_name*/"isSWVLMotrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/56,   /*des_updatebit*/500,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/66,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/82,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockChkSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/90,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockChkSteerLockDataChk0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/89,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedLoBeamWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/448,      /*initvalue*/0         },
           {   /*sig_name*/"isIDcDcAvlMaxLoSide_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x14b,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/187,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowRearRiMultiVertSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt2_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt3_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt1_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt5_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrActrFlt4_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachHwFailrDrvrTmrFlt_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntFogLampWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/256,      /*initvalue*/0         },
           {   /*sig_name*/"isSBMHealthChkResp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/24,   /*des_updatebit*/471,      /*initvalue*/0         },
           {   /*sig_name*/"isMosTempFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x2d4,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/10,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCPrpsnTqDistRatio_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/63,   /*des_updatebit*/128,      /*initvalue*/0         },
           {   /*sig_name*/"isAltFltMecl_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/14,   /*des_updatebit*/288,      /*initvalue*/0         },
           {   /*sig_name*/"isHwSwtRowSecLeEasyInOutForThrd2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x21a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/49,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isTcsOvrheatdProtnSts_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/264,      /*initvalue*/0         },
           {   /*sig_name*/"isCurtBtnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/28,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/452,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowFrthMid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/29,   /*des_updatebit*/285,      /*initvalue*/0         },
           {   /*sig_name*/"isWipgAutFrntMod_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/465,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrIndcrTurnSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/6,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isAltNoResp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/10,   /*des_updatebit*/446,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatDownLumPosPercDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/440,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdLeVentnHeatgWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x331,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmHardRotReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/51,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isLMMCommDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/41,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHTRLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHTRLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isSolarSnsrRiValue_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/1000,   /*des_updatebit*/440,      /*initvalue*/51         },
           {   /*sig_name*/"isVFCVectorLPODVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorLPODVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x544,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSnsrHwFltRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdLeOnOff_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/281,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdLeMassgInten_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/281,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdLeMassgProg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/281,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgAntiPnch_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/54,   /*des_updatebit*/469,      /*initvalue*/0         },
           {   /*sig_name*/"isWPRLPhoneForgottenRmn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1,   /*des_updatebit*/450,      /*initvalue*/0         },
           {   /*sig_name*/"isCH2DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/52,   /*des_updatebit*/163,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockStsFault_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/14,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockStsUnit_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/14,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockStsBolt_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/14,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockStsSafety_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/14,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isReFogLiSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/478,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofMvngSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/342,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvgCycToClrPrmntDtc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x220,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/280,      /*initvalue*/0         },
           {   /*sig_name*/"isTwbrWarnStsChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/22,   /*des_updatebit*/385,      /*initvalue*/0         },
           {   /*sig_name*/"isTwbrWarnStsYesNo_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/22,   /*des_updatebit*/385,      /*initvalue*/2         },
           {   /*sig_name*/"isTwbrWarnStsCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/22,   /*des_updatebit*/385,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/432,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/420,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/422,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/443,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/446,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/400,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/440,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/442,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/414,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/434,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/403,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCRPMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x56d,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isPressureFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x2d4,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/59,   /*des_updatebit*/403,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmCluT2Val_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/23,   /*des_updatebit*/344,      /*initvalue*/32         },
           {   /*sig_name*/"isTrsmCluT2Qf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/23,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isElecChromFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapSoc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/37,   /*des_updatebit*/381,      /*initvalue*/0         },
           {   /*sig_name*/"isBattFltStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isBattFltStsPrimBattFltStsPrm_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isBattFltStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x573,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
