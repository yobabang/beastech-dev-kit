           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data3_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data4_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data7_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data2_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data5_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data8_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data6_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igInterLockCom2_0",   /*sig_name*/"isInterLockCom2Data1_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/40         },
           {   /*sigGroup_s*/"igBltCrashNotif_0",   /*sig_name*/"isBltCrashNotifDrvr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/57,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igBltCrashNotif_0",   /*sig_name*/"isBltCrashNotifPass_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_id*/0x4c3, /*updatebit_S*/57,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igPtBrkTqCpTot_0",   /*sig_name*/"isPtBrkTqCpTotQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/22,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igPtBrkTqCpTot_0",   /*sig_name*/"isPtBrkTqCpTot1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/22,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igTVCReWhlSteerCtrlStsForTvc_0",   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/40,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igTVCReWhlSteerCtrlStsForTvc_0",   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/40,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igTVCReWhlSteerCtrlStsForTvc_0",   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcTVCReWhlSteerCtrlStsForTvc_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/40,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsThirdRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsThirdRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsSecondRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsSecondRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsFirstRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igReadLiSts_0",   /*sig_name*/"isReadLiStsFirstRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igPtTotRgnTarTq_0",   /*sig_name*/"isPtTotRgnTarTq1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/125,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/140,   /*updatebit_D*/260         },
           {   /*sigGroup_s*/"igPtTotRgnTarTq_0",   /*sig_name*/"isPtTotRgnTarTqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/142,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/262,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/140,   /*updatebit_D*/260         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igBMS2FltStsADataD_0",   /*sig_name*/"isBMS2FltStsADataDData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/248         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/119,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBCnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/70,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBData4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igPrpsnDataEvtB_0",   /*sig_name*/"isPrpsnDataEvtBID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_id*/0x43, /*updatebit_S*/71,   /*updatebit_D*/120         },
           {   /*sigGroup_s*/"igGVMCSteerCtrlModCfmd_0",   /*sig_name*/"isGVMCSteerCtrlModCfmdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/40,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igGVMCSteerCtrlModCfmd_0",   /*sig_name*/"isGVMCSteerCtrlModCfmdGVMCSteerCtrlModCfmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/40,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igGVMCSteerCtrlModCfmd_0",   /*sig_name*/"isGVMCSteerCtrlModCfmdMainSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/40,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igGVMCSteerCtrlModCfmd_0",   /*sig_name*/"isGVMCSteerCtrlModCfmdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_id*/0x2e5, /*updatebit_S*/40,   /*updatebit_D*/233         },
           {   /*sigGroup_s*/"igTrsmEngmtLimd3_0",   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/5,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igTrsmEngmtLimd3_0",   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/5,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igTrsmEngmtLimd3_0",   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/5,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupAgAct_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupSteerActrReSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupAgGrdtMaxAvlFromSteerActrRe_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupAgMaxAvlFromSteerActrRe_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupAgActQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igSteerActReGroup_0",   /*sig_name*/"isSteerActReGroupChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/7,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igHWASyncStsGroupH1_0",   /*sig_name*/"isHWASyncStsGroupH1SyncSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/0,   /*updatebit_D*/442         },
           {   /*sigGroup_s*/"igHWASyncStsGroupH1_0",   /*sig_name*/"isHWASyncStsGroupH1SyncOvrdIndcn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/0,   /*updatebit_D*/442         },
           {   /*sigGroup_s*/"igTVCTqDistbnFaultForGVMC_0",   /*sig_name*/"isTVCTqDistbnFaultForGVMCTVCTqDistbnFaultForGVMC_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/193         },
           {   /*sigGroup_s*/"igTVCTqDistbnFaultForGVMC_0",   /*sig_name*/"isTVCTqDistbnFaultForGVMCCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/193         },
           {   /*sigGroup_s*/"igTVCTqDistbnFaultForGVMC_0",   /*sig_name*/"isTVCTqDistbnFaultForGVMCChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/193         },
           {   /*sigGroup_s*/"igBtnStsOHC_0",   /*sig_name*/"isBtnStsOHCLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igBtnStsOHC_0",   /*sig_name*/"isBtnStsOHCLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igBtnStsOHC_0",   /*sig_name*/"isBtnStsOHCIntrLiSwtAutOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igBtnStsOHC_0",   /*sig_name*/"isBtnStsOHCIntrLiSwtAllOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/219         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSDR_0",   /*sig_name*/"isVFCVectorSDRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthRi_0",   /*sig_name*/"isBltLockStAtRowFrthRiBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/44,   /*updatebit_D*/224         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthRi_0",   /*sig_name*/"isBltLockStAtRowFrthRiBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/44,   /*updatebit_D*/224         },
           {   /*sigGroup_s*/"igBltLockStAtRowFrthRi_0",   /*sig_name*/"isBltLockStAtRowFrthRiBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/44,   /*updatebit_D*/224         },
           {   /*sigGroup_s*/"igRowSecLeHeiPosPerc_0",   /*sig_name*/"isRowSecLeHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_id*/0x281, /*updatebit_S*/20,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igRowSecLeHeiPosPerc_0",   /*sig_name*/"isRowSecLeHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_id*/0x281, /*updatebit_S*/20,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igSBWSysDegradationStsR2_0",   /*sig_name*/"isSBWSysDegradationStsR2DegradationSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/5,   /*updatebit_D*/136         },
           {   /*sigGroup_s*/"igSBWSysDegradationStsR2_0",   /*sig_name*/"isSBWSysDegradationStsR2Chks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/5,   /*updatebit_D*/136         },
           {   /*sigGroup_s*/"igSBWSysDegradationStsR2_0",   /*sig_name*/"isSBWSysDegradationStsR2Cntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/5,   /*updatebit_D*/136         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataEData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igBMS2FltStsADataE_0",   /*sig_name*/"isBMS2FltStsADataECnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_id*/0x3b5, /*updatebit_S*/1000,   /*updatebit_D*/312         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecOutpQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecOutp_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInpQf1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInpQf2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecOutpDir_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInpDir2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInp2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInpDir1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igTrsmNRec_0",   /*sig_name*/"isTrsmNRecInp1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/7,   /*updatebit_D*/272         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPC_0",   /*sig_name*/"isVFCVectorWPCVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBR_0",   /*sig_name*/"isVFCVectorSMBRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igBltLockStAtRowThrdMid_0",   /*sig_name*/"isBltLockStAtRowThrdMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/40,   /*updatebit_D*/236         },
           {   /*sigGroup_s*/"igBltLockStAtRowThrdMid_0",   /*sig_name*/"isBltLockStAtRowThrdMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/40,   /*updatebit_D*/236         },
           {   /*sigGroup_s*/"igBltLockStAtRowThrdMid_0",   /*sig_name*/"isBltLockStAtRowThrdMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_id*/0x331, /*updatebit_S*/40,   /*updatebit_D*/236         },
           {   /*sigGroup_s*/"igBattSOCLiCell_0",   /*sig_name*/"isBattSOCLiCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igBattSOCLiCell_0",   /*sig_name*/"isBattSOCLiCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igBattSOCLiCell_0",   /*sig_name*/"isBattSOCLiCell4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igBattSOCLiCell_0",   /*sig_name*/"isBattSOCLiCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/88         },
           {   /*sigGroup_s*/"igOutdBri_0",   /*sig_name*/"isOutdBriSts_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igOutdBri_0",   /*sig_name*/"isOutdBriChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igOutdBri_0",   /*sig_name*/"isOutdBriCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igDoorDrvrReObstPos2_0",   /*sig_name*/"isDoorDrvrReObstPos2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igDoorDrvrReObstPos2_0",   /*sig_name*/"isDoorDrvrReObstPos2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igDoorDrvrReObstPos2_0",   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosX_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igDoorDrvrReObstPos2_0",   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosY_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igDoorDrvrReObstPos2_0",   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosZ_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/451         },
           {   /*sigGroup_s*/"igPtRgnTarTqAtReAxle_0",   /*sig_name*/"isPtRgnTarTqAtReAxleQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/112,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/126,   /*updatebit_D*/246         },
           {   /*sigGroup_s*/"igPtRgnTarTqAtReAxle_0",   /*sig_name*/"isPtRgnTarTqAtReAxleAtReAxle_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/126,   /*updatebit_D*/246         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1FltSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/154,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/146,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1FiveMinRuleSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/172,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1MaiSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1HealthSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/174,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1SteerErr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/164,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1TankTurnState_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/161,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1FltDateStoreFlag_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/171,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1SbWSysStR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/158,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igPubCANRWASysR1Group1_0",   /*sig_name*/"isPubCANRWASysR1Group1FctModCfmd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/170,   /*updatebit_D*/266         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDDRM_0",   /*sig_name*/"isVFCVectorDDRMVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igEpbLampReqSec_0",   /*sig_name*/"isEpbLampReqSecEpbLampReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/41,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igEpbLampReqSec_0",   /*sig_name*/"isEpbLampReqSecChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/41,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igEpbLampReqSec_0",   /*sig_name*/"isEpbLampReqSecCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/41,   /*updatebit_D*/96         },
           {   /*sigGroup_s*/"igDoorSldngRiReSts_0",   /*sig_name*/"isDoorSldngRiReStsDoorOpenSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/32,   /*updatebit_D*/498         },
           {   /*sigGroup_s*/"igDoorSldngRiReSts_0",   /*sig_name*/"isDoorSldngRiReStsFrstTmLveAbnd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/32,   /*updatebit_D*/498         },
           {   /*sigGroup_s*/"igSldngdoorLeReAntiPnchFault_0",   /*sig_name*/"isSldngdoorLeReAntiPnchFaultPinchEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/16,   /*updatebit_D*/109         },
           {   /*sigGroup_s*/"igSldngdoorLeReAntiPnchFault_0",   /*sig_name*/"isSldngdoorLeReAntiPnchFaultFltMovngEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x390, /*updatebit_S*/16,   /*updatebit_D*/109         },
           {   /*sigGroup_s*/"igWiprMotDiagc_0",   /*sig_name*/"isWiprMotDiagcWiprMotLoVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igWiprMotDiagc_0",   /*sig_name*/"isWiprMotDiagcWiprMotHiVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igWiprMotDiagc_0",   /*sig_name*/"isWiprMotDiagcWiprMotOvldDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/433         },
           {   /*sigGroup_s*/"igDoorDrvrRePosnToObst2_0",   /*sig_name*/"isDoorDrvrRePosnToObst2AngleDeg11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/453         },
           {   /*sigGroup_s*/"igDoorDrvrRePosnToObst2_0",   /*sig_name*/"isDoorDrvrRePosnToObst2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/453         },
           {   /*sigGroup_s*/"igDoorDrvrRePosnToObst2_0",   /*sig_name*/"isDoorDrvrRePosnToObst2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/59,   /*updatebit_D*/453         },
           {   /*sigGroup_s*/"igSRSResdSig1ToZCUDMSafety_0",   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/43,   /*updatebit_D*/320         },
           {   /*sigGroup_s*/"igSRSResdSig1ToZCUDMSafety_0",   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyUInt32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/32,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/43,   /*updatebit_D*/320         },
           {   /*sigGroup_s*/"igSRSResdSig1ToZCUDMSafety_0",   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/43,   /*updatebit_D*/320         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdRi_0",   /*sig_name*/"isSeatMassgFctRowThrdRiMassgProg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdRi_0",   /*sig_name*/"isSeatMassgFctRowThrdRiOnOff_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igSeatMassgFctRowThrdRi_0",   /*sig_name*/"isSeatMassgFctRowThrdRiMassgInten_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/8,   /*updatebit_D*/289         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid26_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid14_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid36_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid22_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid15_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid38_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid31_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid61_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid60_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid37_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid42_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid28_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid47_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid46_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid32_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid27_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid44_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid30_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid23_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid7_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid55_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid21_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid17_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid54_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid29_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid57_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid56_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid9_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid18_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid45_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid25_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid12_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid16_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid48_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid11_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid13_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid24_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid39_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid19_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid49_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid53_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid33_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid43_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid41_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASBlockID_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid8_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid10_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid35_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid58_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid59_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid34_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid40_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid51_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid52_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid20_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSAS_0",   /*sig_name*/"isVFCVectorSASVFCid50_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igSecBrkSysSt_0",   /*sig_name*/"isSecBrkSysStCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/47,   /*updatebit_D*/178         },
           {   /*sigGroup_s*/"igSecBrkSysSt_0",   /*sig_name*/"isSecBrkSysStBrkSysSt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/47,   /*updatebit_D*/178         },
           {   /*sigGroup_s*/"igSecBrkSysSt_0",   /*sig_name*/"isSecBrkSysStChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/47,   /*updatebit_D*/178         },
           {   /*sigGroup_s*/"igSunRoofAndCurtBtnSts2_0",   /*sig_name*/"isSunRoofAndCurtBtnSts2Cntr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x331, /*updatebit_S*/1000,   /*updatebit_D*/466         },
           {   /*sigGroup_s*/"igSunRoofAndCurtBtnSts2_0",   /*sig_name*/"isSunRoofAndCurtBtnSts2Pos_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x331, /*updatebit_S*/1000,   /*updatebit_D*/466         },
           {   /*sigGroup_s*/"igIsgTqReq_0",   /*sig_name*/"isIsgTqReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/195,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igIsgTqReq_0",   /*sig_name*/"isIsgTqReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/195,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igIsgTqReq_0",   /*sig_name*/"isIsgTqReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/197,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/195,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igIsgTqReq_0",   /*sig_name*/"isIsgTqReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/177,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/195,   /*updatebit_D*/169         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorWPRL_0",   /*sig_name*/"isVFCVectorWPRLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igRowSecRiRotSwt2_0",   /*sig_name*/"isRowSecRiRotSwt2BtnModA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/52         },
           {   /*sigGroup_s*/"igRowSecRiRotSwt2_0",   /*sig_name*/"isRowSecRiRotSwt2BtnModC_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/52         },
           {   /*sigGroup_s*/"igRowSecRiRotSwt2_0",   /*sig_name*/"isRowSecRiRotSwt2BtnModB_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_id*/0x141, /*updatebit_S*/41,   /*updatebit_D*/52         },
           {   /*sigGroup_s*/"igDmcStsFrntToEsc_0",   /*sig_name*/"isDmcStsFrntToEscDmcSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/219,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/113,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igDmcStsFrntToEsc_0",   /*sig_name*/"isDmcStsFrntToEscCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/113,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igDmcStsFrntToEsc_0",   /*sig_name*/"isDmcStsFrntToEscChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/215,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/113,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igDmcStsFrntToEsc_0",   /*sig_name*/"isDmcStsFrntToEscDmcActAppTarTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/113,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igDmcStsFrntToEsc_0",   /*sig_name*/"isDmcStsFrntToEscDmcSWInfo_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/113,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igDoorSldngRiReCinFail_0",   /*sig_name*/"isDoorSldngRiReCinFailCinchRestFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/19,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igDoorSldngRiReCinFail_0",   /*sig_name*/"isDoorSldngRiReCinFailCinchFlt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/19,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorPOT_0",   /*sig_name*/"isVFCVectorPOTVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igIntrLiCmdGroup_0",   /*sig_name*/"isIntrLiCmdGroupIntrLiRoofDim_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/292         },
           {   /*sigGroup_s*/"igIntrLiCmdGroup_0",   /*sig_name*/"isIntrLiCmdGroupIntrLiActvn_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/292         },
           {   /*sigGroup_s*/"igIntrLiCmdGroup_0",   /*sig_name*/"isIntrLiCmdGroupIntrLiRoofDmdOff_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/292         },
           {   /*sigGroup_s*/"igSBWFltStsR1_0",   /*sig_name*/"isSBWFltStsR1FltStsH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/35,   /*updatebit_D*/355         },
           {   /*sigGroup_s*/"igSBWFltStsR1_0",   /*sig_name*/"isSBWFltStsR1FltStsR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/35,   /*updatebit_D*/355         },
           {   /*sigGroup_s*/"igSBWFltStsR1_0",   /*sig_name*/"isSBWFltStsR1FltStsR2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/35,   /*updatebit_D*/355         },
           {   /*sigGroup_s*/"igSBWFltStsR1_0",   /*sig_name*/"isSBWFltStsR1FltStsH2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_id*/0x2e3, /*updatebit_S*/35,   /*updatebit_D*/355         },
           {   /*sigGroup_s*/"igIntrMirrResp_0",   /*sig_name*/"isIntrMirrRespIntrMirrIntFailr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/8         },
           {   /*sigGroup_s*/"igIntrMirrResp_0",   /*sig_name*/"isIntrMirrRespResdUInt6_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/8         },
           {   /*sigGroup_s*/"igIntrMirrResp_0",   /*sig_name*/"isIntrMirrRespIntrMirrDimPerc_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/8         },
           {   /*sigGroup_s*/"igIntrMirrResp_0",   /*sig_name*/"isIntrMirrRespResdBoolean_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_id*/0x25f, /*updatebit_S*/1000,   /*updatebit_D*/8         },
           {   /*sigGroup_s*/"igDoorSldngLeReCinFail_0",   /*sig_name*/"isDoorSldngLeReCinFailCinchRestFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/19,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igDoorSldngLeReCinFail_0",   /*sig_name*/"isDoorSldngLeReCinFailCinchFlt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x220, /*updatebit_S*/19,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igBattRlyStsPrim_0",   /*sig_name*/"isBattRlyStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/465         },
           {   /*sigGroup_s*/"igBattRlyStsPrim_0",   /*sig_name*/"isBattRlyStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/465         },
           {   /*sigGroup_s*/"igBattRlyStsPrim_0",   /*sig_name*/"isBattRlyStsPrimSwtSts_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/465         },
           {   /*sigGroup_s*/"igRowSecLeLegRstLenPosPerc_0",   /*sig_name*/"isRowSecLeLegRstLenPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/28,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igRowSecLeLegRstLenPosPerc_0",   /*sig_name*/"isRowSecLeLegRstLenPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/28,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/157,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1FltDateStoreFlag_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/180,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1SteerErr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/170,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1FiveMinRuleSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/181,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/165,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1HealthSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1FltSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/173,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1SysDegradeReason_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/161,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igPubCANHWASysH1Group1_0",   /*sig_name*/"isPubCANHWASysH1Group1SysDegradeReasonVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/179,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/178,   /*updatebit_D*/459         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeALgt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeALgt1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeALat_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeAVert_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeALat1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeAVertQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igADataRawSafe_0",   /*sig_name*/"isADataRawSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNInp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/455,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNOutp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/456,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNOutpOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/492,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNInpOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/493,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/481,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igTrsmN_0",   /*sig_name*/"isTrsmNChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/473,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x2e5, /*updatebit_S*/509,   /*updatebit_D*/91         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDPOD_0",   /*sig_name*/"isVFCVectorDPODVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igPropLgtCtrlModCfmd_0",   /*sig_name*/"isPropLgtCtrlModCfmdPropLgtCtrlModCfmd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/69,   /*updatebit_D*/201         },
           {   /*sigGroup_s*/"igPropLgtCtrlModCfmd_0",   /*sig_name*/"isPropLgtCtrlModCfmdLgtDegradation_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/69,   /*updatebit_D*/201         },
           {   /*sigGroup_s*/"igPropLgtCtrlModCfmd_0",   /*sig_name*/"isPropLgtCtrlModCfmdChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/69,   /*updatebit_D*/201         },
           {   /*sigGroup_s*/"igPropLgtCtrlModCfmd_0",   /*sig_name*/"isPropLgtCtrlModCfmdCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/69,   /*updatebit_D*/201         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReLe_0",   /*sig_name*/"isMotDynCtrlStsReLeCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/87,   /*updatebit_D*/353         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReLe_0",   /*sig_name*/"isMotDynCtrlStsReLeDmcSWInfo_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/87,   /*updatebit_D*/353         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReLe_0",   /*sig_name*/"isMotDynCtrlStsReLeDmcActAppTarTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/87,   /*updatebit_D*/353         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReLe_0",   /*sig_name*/"isMotDynCtrlStsReLeDmcSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/147,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/87,   /*updatebit_D*/353         },
           {   /*sigGroup_s*/"igMotDynCtrlStsReLe_0",   /*sig_name*/"isMotDynCtrlStsReLeChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/87,   /*updatebit_D*/353         },
           {   /*sigGroup_s*/"igRowSecRiSldPosPerc_0",   /*sig_name*/"isRowSecRiSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/51,   /*updatebit_D*/315         },
           {   /*sigGroup_s*/"igRowSecRiSldPosPerc_0",   /*sig_name*/"isRowSecRiSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/51,   /*updatebit_D*/315         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtAxleFrntAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlFrntLeAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlsFrntQly_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlFrntRiAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPtTqAtWhlFrntAct_0",   /*sig_name*/"isPtTqAtWhlFrntActChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x80, /*updatebit_S*/56,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSUM_0",   /*sig_name*/"isVFCVectorSUMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igSteerColRatGroupH1_0",   /*sig_name*/"isSteerColRatGroupH1RatMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/51,   /*updatebit_D*/19         },
           {   /*sigGroup_s*/"igSteerColRatGroupH1_0",   /*sig_name*/"isSteerColRatGroupH1SteerRatVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/51,   /*updatebit_D*/19         },
           {   /*sigGroup_s*/"igWhlMotSysRiTqAvl_0",   /*sig_name*/"isWhlMotSysRiTqAvlTqAvlMin_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/145,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/163,   /*updatebit_D*/470         },
           {   /*sigGroup_s*/"igWhlMotSysRiTqAvl_0",   /*sig_name*/"isWhlMotSysRiTqAvlTqAvlMax_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/163,   /*updatebit_D*/470         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorCMD_0",   /*sig_name*/"isVFCVectorCMDVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
