           {   /*sig_name*/"isNewBattFltStsPrimReserved1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimScFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimFaultLevel_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimOvFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimThermRunawayFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimPreThermRunawayFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimUvFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isNewBattFltStsPrimReserved0_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isLobmE2EDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x25f,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/5,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqReReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/379,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/377,   /*des_updatebit*/153,      /*initvalue*/3         },
           {   /*sig_name*/"isPrpsnTqReReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/377,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqReReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/377,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqReReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/359,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/377,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isStreamingMirrBri_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/251,      /*initvalue*/10         },
           {   /*sig_name*/"isPtRotReqAckd1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/50,   /*des_updatebit*/128,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeasIntlIntl1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeasIntlIntl2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeasIntlIntl4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeasIntlIntl3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofMoveDir2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/194,      /*initvalue*/0         },
           {   /*sig_name*/"isTrRelsFailtoHMI_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/23,   /*des_updatebit*/400,      /*initvalue*/0         },
           {   /*sig_name*/"isDCMotrCtrlDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/48,   /*des_updatebit*/104,      /*initvalue*/0         },
           {   /*sig_name*/"isRelHumSnsrErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c2, /*src_updatebit*/1000,   /*des_updatebit*/384,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtImpctDetnSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isRowReRiSldAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/33,   /*des_updatebit*/21,      /*initvalue*/0         },
           {   /*sig_name*/"isLMMLedDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/40,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerLockChkSteerLockDataChk5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1,   /*des_updatebit*/414,      /*initvalue*/0         },
           {   /*sig_name*/"isTqAssAddl_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/54,   /*des_updatebit*/469,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid16_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid30_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid50_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid46_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid36_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid45_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid47_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid49_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid18_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid32_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid38_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid15_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid19_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid42_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid20_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid10_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid53_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid41_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid24_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid13_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid25_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid8_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid9_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid54_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid40_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid56_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid57_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid31_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid14_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid27_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid26_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid44_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid28_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid61_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid60_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid51_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid23_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid12_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid34_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid17_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid52_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid55_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid11_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid21_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid33_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid22_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid39_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid35_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid37_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid48_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid58_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADBlockID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid43_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid29_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDSADVFCid59_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtAxleAvlReMax_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/504,   /*des_updatebit*/370,      /*initvalue*/0         },
           {   /*sig_name*/"isTankTurnRotateActRoad_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/427,   /*des_updatebit*/467,      /*initvalue*/0         },
           {   /*sig_name*/"isCH5DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/58,   /*des_updatebit*/211,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCRLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCRLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isCH6DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/59,   /*des_updatebit*/227,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtTrClsSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/6,   /*des_updatebit*/482,      /*initvalue*/0         },
           {   /*sig_name*/"isCfgPrmStsFromKnkSnsr_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/12,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/208,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdLeSldAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/61,   /*des_updatebit*/69,      /*initvalue*/0         },
           {   /*sig_name*/"isCH11DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/49,   /*des_updatebit*/115,      /*initvalue*/0         },
           {   /*sig_name*/"isTrLatPosn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x242,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/50,   /*des_updatebit*/456,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsCmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/16,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowThrdLeFldRsdSwtSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/24,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSteerFEstimd1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/56,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isBattCpEstimdRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/376,      /*initvalue*/80         },
           {   /*sig_name*/"isTrlrLiFltSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/22,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapCurr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/15,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiEasyInOutRstSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/40,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbLampStsRecPassAirbLampStsCntr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/265,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbLampStsRecPassAirbLampStsChks_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/265,      /*initvalue*/255         },
           {   /*sig_name*/"isPassAirbLampStsRecPassAirbLampSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/265,      /*initvalue*/1         },
           {   /*sig_name*/"isElecStepFltTmrFlt_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isElecStepFltActrFlt4_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isElecStepFltActrFlt1_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isElecStepFltActrFlt3_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isElecStepFltActrFlt5_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isElecStepFltActrFlt2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isPtGearActrAdpnCmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/6,   /*des_updatebit*/130,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgLvlStsRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x341,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/53,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh2Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/2,   /*des_updatebit*/162,      /*initvalue*/0         },
           {   /*sig_name*/"isHWARefHandWhlTqH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/89,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReAntiPnch2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/6,   /*des_updatebit*/450,      /*initvalue*/0         },
           {   /*sig_name*/"isCH4DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/57,   /*des_updatebit*/203,      /*initvalue*/0         },
           {   /*sig_name*/"isHCML2DTCGroup3_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/112,      /*initvalue*/0         },
           {   /*sig_name*/"isCH8DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/61,   /*des_updatebit*/259,      /*initvalue*/0         },
           {   /*sig_name*/"isCmptFrntWindDewT_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/332,      /*initvalue*/600         },
           {   /*sig_name*/"isTrsmCluT1Val_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/3,   /*des_updatebit*/340,      /*initvalue*/32         },
           {   /*sig_name*/"isTrsmCluT1Qf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/3,   /*des_updatebit*/340,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR2FltStsH1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/19,   /*des_updatebit*/363,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR2FltStsR1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/19,   /*des_updatebit*/363,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR2FltStsH2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/19,   /*des_updatebit*/363,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR2FltStsR2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/19,   /*des_updatebit*/363,      /*initvalue*/0         },
           {   /*sig_name*/"isHoodAntiPnch_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/6,   /*des_updatebit*/81,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTiToCluEngmt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/501,   /*des_updatebit*/407,      /*initvalue*/255         },
           {   /*sig_name*/"isOxygenSplyDesPwrCns_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x2c0,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/12,   /*des_updatebit*/370,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedCornrgLampwithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/208,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtAxleAvlFrntMin_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/503,   /*des_updatebit*/354,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtIntmIntlCmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/40,   /*des_updatebit*/188,      /*initvalue*/4         },
           {   /*sig_name*/"isFloatDrvingActvChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/32,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrvingActvStatus_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/32,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrvingActvCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/32,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isCH11DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/49,   /*des_updatebit*/123,      /*initvalue*/0         },
           {   /*sig_name*/"isBattULiCellBattUCell4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/409,      /*initvalue*/0         },
           {   /*sig_name*/"isBattULiCellBattUCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/409,      /*initvalue*/0         },
           {   /*sig_name*/"isBattULiCellBattUCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/409,      /*initvalue*/0         },
           {   /*sig_name*/"isBattULiCellBattUCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/409,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrUFltLoVoltDetdFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/481,      /*initvalue*/0         },
           {   /*sig_name*/"isActvReSplrUFltHiVoltDetdFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/481,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntTurnIndcrWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/288,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqFrntReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/409,   /*des_updatebit*/121,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqFrntReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/411,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/409,   /*des_updatebit*/121,      /*initvalue*/3         },
           {   /*sig_name*/"isPrpsnTqFrntReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/415,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/409,   /*des_updatebit*/121,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnTqFrntReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/407,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/409,   /*des_updatebit*/121,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrDoorSpindleMotorFault_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x1d0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/19,   /*des_updatebit*/331,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtModBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtDwnBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtCmfBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtCustBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtRiBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtUpBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtVoiceBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtLeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtViewBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtReserveBtn1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtHomeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtMuteBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtMenuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/198,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtBoostBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlEntertainmentSwtReserveBtn2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/24,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentAvlStsRowSecRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/4,   /*des_updatebit*/412,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSCmprStrtFlt2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/340,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockWarnIndcn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/101,   /*des_updatebit*/237,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh6Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/9,   /*des_updatebit*/106,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorHVFMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4bb, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiInclPosAngle_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/13,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data3_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data4_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data7_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data2_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data5_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data8_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data6_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isInterLockCom2Data1_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/59,   /*src_dlc*/8,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/40,      /*initvalue*/0         },
           {   /*sig_name*/"isObstStrDrvrRe_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/33,   /*des_updatebit*/404,      /*initvalue*/0         },
           {   /*sig_name*/"isMcuTempSnsrErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/25,   /*des_updatebit*/234,      /*initvalue*/0         },
           {   /*sig_name*/"isLsmClimaPwrSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/336,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRiVentnHeatgWarnSMX_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/61,   /*des_updatebit*/338,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtAxleAvlReMin_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/505,   /*des_updatebit*/288,      /*initvalue*/0         },
           {   /*sig_name*/"isHCML2DTCGroup2_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isBattCycDchaCntrDurgQuiscPhaRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/209,      /*initvalue*/0         },
           {   /*sig_name*/"isBltCrashNotifDrvr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/57,   /*des_updatebit*/451,      /*initvalue*/0         },
           {   /*sig_name*/"isBltCrashNotifPass_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/57,   /*des_updatebit*/451,      /*initvalue*/0         },
           {   /*sig_name*/"isRainDetected_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/258,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngLeReWarnSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/42,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntWshrSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/491,      /*initvalue*/0         },
           {   /*sig_name*/"isObstStrDetcnDrvrRe2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/38,   /*des_updatebit*/392,      /*initvalue*/0         },
           {   /*sig_name*/"isPtBrkTqCpTotQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/22,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isPtBrkTqCpTot1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/22,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isPOSLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/57,   /*des_updatebit*/57,      /*initvalue*/0         },
           {   /*sig_name*/"isEgyMeasSec_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/140,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/40,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/40,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCReWhlSteerCtrlStsForTvcTVCReWhlSteerCtrlStsForTvc_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/40,   /*des_updatebit*/176,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsThirdRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsThirdRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsSecondRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsSecondRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsFirstRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiStsFirstRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isLobmE2EDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x25e,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/5,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isKnkDetnSts_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/12,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/496,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCWrcActvFlgForFrntAxle_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/161,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4c1, /*src_updatebit*/160,   /*des_updatebit*/338,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh7Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/114,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTotRgnTarTq1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/125,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/140,   /*des_updatebit*/260,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTotRgnTarTqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/142,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/262,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/140,   /*des_updatebit*/260,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrRvsgLiSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/11,   /*des_updatebit*/384,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDCnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataDData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isObstStrDrvr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/33,   /*des_updatebit*/406,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmGbxActrOff_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x13a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/37,   /*des_updatebit*/306,      /*initvalue*/0         },
           {   /*sig_name*/"isEngPAmbAir_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/9,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh8Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/18,   /*des_updatebit*/210,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/119,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBCnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/70,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBData4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnDataEvtBID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/71,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenConcSnsrStsFrmOGM_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/17,   /*des_updatebit*/360,      /*initvalue*/0         },
           {   /*sig_name*/"isGVMCSteerCtrlModCfmdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isGVMCSteerCtrlModCfmdGVMCSteerCtrlModCfmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isGVMCSteerCtrlModCfmdMainSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isGVMCSteerCtrlModCfmdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/40,   /*des_updatebit*/233,      /*initvalue*/0         },
           {   /*sig_name*/"isAutWinWipgCmd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/1000,   /*des_updatebit*/476,      /*initvalue*/0         },
           {   /*sig_name*/"isCH12DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/50,   /*des_updatebit*/139,      /*initvalue*/0         },
           {   /*sig_name*/"isAltI_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/42,   /*des_updatebit*/337,      /*initvalue*/0         },
           {   /*sig_name*/"isHCMR2DTCGroup3_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/128,      /*initvalue*/0         },
           {   /*sig_name*/"isTrCrashUnlckSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x1a0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/6,   /*des_updatebit*/494,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimdCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/5,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/5,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmEngmtLimd3TrsmEngmtLimdChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/5,   /*des_updatebit*/322,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupAgAct_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupSteerActrReSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupAgGrdtMaxAvlFromSteerActrRe_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/4096         },
           {   /*sig_name*/"isSteerActReGroupCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupAgMaxAvlFromSteerActrRe_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupAgActQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerActReGroupChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x45,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/7,   /*des_updatebit*/59,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmGearActrTLvl_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/53,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isTrAntiPnch_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/300,   /*des_id*/0x371, /*src_updatebit*/9,   /*des_updatebit*/38,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/19,   /*des_updatebit*/483,      /*initvalue*/0         },
           {   /*sig_name*/"isADC2DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/12,   /*des_updatebit*/332,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrAntiPnch2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/6,   /*des_updatebit*/442,      /*initvalue*/0         },
           {   /*sig_name*/"isCVCH1DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/43,   /*des_updatebit*/291,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgCmftHwFailrDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/208,      /*initvalue*/0         },
           {   /*sig_name*/"isHWASyncStsGroupH1SyncSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/0,   /*des_updatebit*/442,      /*initvalue*/0         },
           {   /*sig_name*/"isHWASyncStsGroupH1SyncOvrdIndcn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/0,   /*des_updatebit*/442,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMTempErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/1,   /*des_updatebit*/17,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmGearActrScanForRefReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x13a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/21,   /*des_updatebit*/308,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCTqDistbnFaultForGVMCTVCTqDistbnFaultForGVMC_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/193,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCTqDistbnFaultForGVMCCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/193,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCTqDistbnFaultForGVMCChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/62,   /*des_updatebit*/193,      /*initvalue*/0         },
           {   /*sig_name*/"isLogoLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/10,   /*des_updatebit*/314,      /*initvalue*/0         },
           {   /*sig_name*/"isHwSwtRowSecRiEasyInOutForThrd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/48,   /*des_updatebit*/400,      /*initvalue*/0         },
           {   /*sig_name*/"isPtParkReqToWhlsRe_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/40,   /*des_updatebit*/345,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh5Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/10,   /*des_updatebit*/186,      /*initvalue*/0         },
           {   /*sig_name*/"isThrPos_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/40,   /*des_updatebit*/468,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/219,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/219,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCIntrLiSwtAutOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/219,      /*initvalue*/0         },
           {   /*sig_name*/"isBtnStsOHCIntrLiSwtAllOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/20,   /*src_dlc*/1,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/219,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmParkAutRdy_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/247,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/246,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSDRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x558,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtRowFrthRiBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/44,   /*des_updatebit*/224,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowFrthRiBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/44,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtRowFrthRiBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/44,   /*des_updatebit*/224,      /*initvalue*/1         },
           {   /*sig_name*/"isBattDchaAbty_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/1000,   /*des_updatebit*/97,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtBeamHi_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/24,   /*des_updatebit*/149,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMFlowFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x2eb,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/54,   /*des_updatebit*/358,      /*initvalue*/0         },
           {   /*sig_name*/"isBoostBuckErrDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/33,   /*des_updatebit*/89,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/20,   /*des_updatebit*/443,      /*initvalue*/1000         },
           {   /*sig_name*/"isRowSecLeHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/20,   /*des_updatebit*/443,      /*initvalue*/0         },
           {   /*sig_name*/"isUpprLowrTailgCtrlInhbFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/40,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isAdjSpdLimnStbOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/399,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/398,   /*des_updatebit*/496,      /*initvalue*/0         },
           {   /*sig_name*/"isDiagcSigLSM2_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/475,      /*initvalue*/0         },
           {   /*sig_name*/"isNotifForEmgyCall_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x22f,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/26,   /*des_updatebit*/396,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgCushBlstrFailrDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/310,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWSysDegradationStsR2DegradationSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/5,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWSysDegradationStsR2Chks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/5,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWSysDegradationStsR2Cntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/5,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isRoofBtnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/28,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/456,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataEData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataECnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/38,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockSts2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/59,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecOutpQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecOutp_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInpQf1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInpQf2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecOutpDir_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInpDir2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInp2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInpDir1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNRecInp1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x30,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/7,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowSeatHeatgDesPwrCnsRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/26,   /*des_updatebit*/475,      /*initvalue*/0         },
           {   /*sig_name*/"isStrtMsgToModMngt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/239,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/236,   /*des_updatebit*/148,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorMaxOpnSetStsDrvrRe_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/16,   /*des_updatebit*/256,      /*initvalue*/101         },
           {   /*sig_name*/"isChdPrtnLeftSwReq_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPCVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isHCMR2DTCGroup2_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/129,      /*initvalue*/0         },
           {   /*sig_name*/"isDrvrPrpsnTqReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/23,   /*des_updatebit*/141,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSnsrCalcnNotVldRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isBattAgeSts_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/1000,   /*des_updatebit*/100,      /*initvalue*/0         },
           {   /*sig_name*/"isSolarSnsrLeValue_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/1000,   /*des_updatebit*/424,      /*initvalue*/51         },
           {   /*sig_name*/"isCH3DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/56,   /*des_updatebit*/179,      /*initvalue*/0         },
           {   /*sig_name*/"isBattTiInSrvRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/315,      /*initvalue*/0         },
           {   /*sig_name*/"isPhoneForgottenRmnWPC5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x30a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/6,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isBattIMidAvb_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/264,      /*initvalue*/32768         },
           {   /*sig_name*/"isFctOfRiCh10Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/226,      /*initvalue*/0         },
           {   /*sig_name*/"isManSyncnIndcnReqR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/5,   /*des_updatebit*/429,      /*initvalue*/0         },
           {   /*sig_name*/"isWPRLSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/3,   /*des_updatebit*/411,      /*initvalue*/1         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSMBRVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x55a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b1, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isFrontCrossLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isLimSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/36,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtRowThrdMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/40,   /*des_updatebit*/236,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowThrdMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/40,   /*des_updatebit*/236,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtRowThrdMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/40,   /*des_updatebit*/236,      /*initvalue*/0         },
           {   /*sig_name*/"isFrCurtBtnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/28,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/448,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSTNowSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/349,      /*initvalue*/250         },
           {   /*sig_name*/"isDstEstimdToEmptyForDrvgElecPredTyp2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/147,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/152,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedHiBeamWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSOCLiCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSOCLiCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSOCLiCell4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isBattSOCLiCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnLvlStsRowSecRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/18,   /*des_updatebit*/409,      /*initvalue*/0         },
           {   /*sig_name*/"isOutdBriSts_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isOutdBriChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isOutdBriCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/1000,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isPtReqToTrsmActr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/115,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/112,   /*des_updatebit*/340,      /*initvalue*/4         },
           {   /*sig_name*/"isTrlrLeIndcrFltSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/10,   /*des_updatebit*/376,      /*initvalue*/0         },
           {   /*sig_name*/"isADSRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/42,   /*des_updatebit*/26,      /*initvalue*/0         },
           {   /*sig_name*/"isMoleculeVlv1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x2eb,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/35,   /*des_updatebit*/245,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReObstPos2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/451,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrReObstPos2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/451,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosX_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/451,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosY_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/451,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrReObstPos2ObjectPosZ_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/35,   /*des_updatebit*/451,      /*initvalue*/255         },
           {   /*sig_name*/"isTCSFltSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/283,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgEcuIntFailrRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/9,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isFloatDrvingModStsForManMod_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/203,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0xe2,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/200,   /*des_updatebit*/256,      /*initvalue*/0         },
           {   /*sig_name*/"isPtRgnTarTqAtReAxleQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/112,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/126,   /*des_updatebit*/246,      /*initvalue*/0         },
           {   /*sig_name*/"isPtRgnTarTqAtReAxleAtReAxle_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/126,   /*des_updatebit*/246,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiSeatHeatgBtn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/52,   /*des_updatebit*/290,      /*initvalue*/0         },
           {   /*sig_name*/"isChgFilElmWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/28,   /*des_updatebit*/157,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgPnmFailrDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/326,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapTotU_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/36,   /*des_updatebit*/24,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1FltSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/154,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/146,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1FiveMinRuleSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/172,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1MaiSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1HealthSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/174,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1SteerErr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/164,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1TankTurnState_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/161,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1FltDateStoreFlag_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/171,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1SbWSysStR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/158,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANRWASysR1Group1FctModCfmd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/170,   /*des_updatebit*/266,      /*initvalue*/0         },
           {   /*sig_name*/"isHvBattLimnIndcn_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x141,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/31,   /*des_updatebit*/104,      /*initvalue*/0         },
           {   /*sig_name*/"isCH2DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/52,   /*des_updatebit*/171,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDDRMVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbLampReqSecEpbLampReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/41,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbLampReqSecChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/41,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbLampReqSecCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/41,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrHoldingSts_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x1d0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/6,   /*des_updatebit*/374,      /*initvalue*/0         },
           {   /*sig_name*/"isHSD1DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/40,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isDcDcPwrLim_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x12a,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/26,   /*des_updatebit*/354,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowRearRiMultiHozlSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/53,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isMirrDirReq_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/116,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngRiReStsDoorOpenSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/32,   /*des_updatebit*/498,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngRiReStsFrstTmLveAbnd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/32,   /*des_updatebit*/498,      /*initvalue*/0         },
           {   /*sig_name*/"isHiBeamSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngdoorLeReAntiPnchFaultPinchEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/16,   /*des_updatebit*/109,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngdoorLeReAntiPnchFaultFltMovngEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/16,   /*des_updatebit*/109,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprMotDiagcWiprMotLoVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/1         },
           {   /*sig_name*/"isWiprMotDiagcWiprMotHiVoltDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/1         },
           {   /*sig_name*/"isWiprMotDiagcWiprMotOvldDetd_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/1         },
           {   /*sig_name*/"isRowSecRiSeatRotPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/22,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isAESCtrlSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x46,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/20,   /*des_updatebit*/441,      /*initvalue*/0         },
           {   /*sig_name*/"isBotmSnsrStsFromFootOper_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/22,   /*src_dlc*/1,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/440,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowThrdLeFldRsdTrnkSwtSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/25,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isADC2DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/12,   /*des_updatebit*/328,      /*initvalue*/0         },
           {   /*sig_name*/"isUBoostReqBySteerFrnt_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/57,   /*des_updatebit*/470,      /*initvalue*/0         },
           {   /*sig_name*/"isADC4DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/20,   /*des_updatebit*/348,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrRePosnToObst2AngleDeg11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/453,      /*initvalue*/255         },
           {   /*sig_name*/"isDoorDrvrRePosnToObst2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/453,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrRePosnToObst2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x70,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/59,   /*des_updatebit*/453,      /*initvalue*/255         },
           {   /*sig_name*/"isCH9DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/62,   /*des_updatebit*/275,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtPosnSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/74,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiMassgLimtStsFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x185,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/3,   /*des_updatebit*/435,      /*initvalue*/0         },
           {   /*sig_name*/"isDstTrvldVldFromSftyBkp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x22f,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/29,   /*des_updatebit*/134,      /*initvalue*/0         },
           {   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/43,   /*des_updatebit*/320,      /*initvalue*/0         },
           {   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyUInt32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/32,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/43,   /*des_updatebit*/320,      /*initvalue*/0         },
           {   /*sig_name*/"isSRSResdSig1ToZCUDMSafetyChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x274,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/43,   /*des_updatebit*/320,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedDaytiRunngLampWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdRiMassgProg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdRiOnOff_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgFctRowThrdRiMassgInten_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x115,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/289,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid26_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid14_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid36_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/161,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid22_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid15_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid38_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid31_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid61_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid60_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid37_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/160,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid42_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid28_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid47_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/182,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid46_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid32_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
