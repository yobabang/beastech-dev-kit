           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorOGM_0",   /*sig_name*/"isVFCVectorOGMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igRowSecRiLegRstLenPosPerc_0",   /*sig_name*/"isRowSecRiLegRstLenPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/28,   /*updatebit_D*/283         },
           {   /*sigGroup_s*/"igRowSecRiLegRstLenPosPerc_0",   /*sig_name*/"isRowSecRiLegRstLenPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/28,   /*updatebit_D*/283         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqFrntRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/147,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqReLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqReRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqReLeCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqFrntLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqFrntLeCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqReRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/171,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqFrntRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqReLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqReRiCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/205,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqFrntLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igTVCBrkTqReq_0",   /*sig_name*/"isTVCBrkTqReqFrntRiCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/193,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/203,   /*updatebit_D*/131         },
           {   /*sigGroup_s*/"igRainSnsrErr_0",   /*sig_name*/"isRainSnsrErrRainDetnErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igRainSnsrErr_0",   /*sig_name*/"isRainSnsrErrCalErrActv_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igRainSnsrErr_0",   /*sig_name*/"isRainSnsrErrCalErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igRainSnsrErr_0",   /*sig_name*/"isRainSnsrErrRainDetnErrActv_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/243         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtAPABtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtSetBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtSetAndCnclBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtResuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtRiBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtCnclBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtUpBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtTimeGapBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtDwnBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtReserveBtn2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtUpAndResuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igSteerWhlCrsSwt_0",   /*sig_name*/"isSteerWhlCrsSwtLeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/25,   /*updatebit_D*/137         },
           {   /*sigGroup_s*/"igIsgTqAct_0",   /*sig_name*/"isIsgTqActChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/357,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/304,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igIsgTqAct_0",   /*sig_name*/"isIsgTqActIsgTqAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/339,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/304,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igIsgTqAct_0",   /*sig_name*/"isIsgTqActCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/365,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/304,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igIsgTqAct_0",   /*sig_name*/"isIsgTqActQualityFactor_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/361,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/304,   /*updatebit_D*/168         },
           {   /*sigGroup_s*/"igCrashStsSafe_0",   /*sig_name*/"isCrashStsSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_id*/0x43, /*updatebit_S*/5,   /*updatebit_D*/154         },
           {   /*sigGroup_s*/"igCrashStsSafe_0",   /*sig_name*/"isCrashStsSafeSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_id*/0x43, /*updatebit_S*/5,   /*updatebit_D*/154         },
           {   /*sigGroup_s*/"igCrashStsSafe_0",   /*sig_name*/"isCrashStsSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_id*/0x43, /*updatebit_S*/5,   /*updatebit_D*/154         }
       }
   },
   {
       /*des_can*/ "BodyExposedCAN",
       /*networktype*/ "CAN",
       0,
       {
           0
       }
   }
};
}



void settestchannel(int num)
{
  switch(num)
  {
  case 0:

        setBusContext(getBusNameContext("ZCUD_LIN1"));
        teststep("step", "Start test on ZCUD_LIN1");
        break;
  case 1:

        setBusContext(getBusNameContext("CEM_LIN3"));
        teststep("step", "Start test on CEM_LIN3");
        break;
  case 2:

        setBusContext(getBusNameContext("CEM_LIN2"));
        teststep("step", "Start test on CEM_LIN2");
        break;
  case 3:

        setBusContext(getBusNameContext("CEM_LIN6"));
        teststep("step", "Start test on CEM_LIN6");
        break;
  case 4:

        setBusContext(getBusNameContext("CEM_LIN1"));
        teststep("step", "Start test on CEM_LIN1");
        break;
  case 5:

        setBusContext(getBusNameContext("CEM_LIN4"));
        teststep("step", "Start test on CEM_LIN4");
        break;
  case 6:

        setBusContext(getBusNameContext("ZCUD_LIN2"));
        teststep("step", "Start test on ZCUD_LIN2");
        break;
  case 7:

        setBusContext(getBusNameContext("ZCUD_LIN3"));
        teststep("step", "Start test on ZCUD_LIN3");
        break;
  case 8:

        setBusContext(getBusNameContext("CEM_LIN7"));
        teststep("step", "Start test on CEM_LIN7");
        break;
  case 9:

        setBusContext(getBusNameContext("PropulsionCAN"));
        teststep("step", "Start test on PropulsionCAN");
        break;
  case 10:

        setBusContext(getBusNameContext("ChassisCAN1"));
        teststep("step", "Start test on ChassisCAN1");
        break;
  case 11:

        setBusContext(getBusNameContext("ZCU_CANFD1"));
        teststep("step", "Start test on ZCU_CANFD1");
        break;
  case 12:

        setBusContext(getBusNameContext("ZCUD_CANFD3"));
        teststep("step", "Start test on ZCUD_CANFD3");
        break;
  case 13:

        setBusContext(getBusNameContext("ChassisCANFD2"));
        teststep("step", "Start test on ChassisCANFD2");
        break;
  case 14:

        setBusContext(getBusNameContext("ZCUD_CAN1"));
        teststep("step", "Start test on ZCUD_CAN1");
        break;
  case 15:

        setBusContext(getBusNameContext("ZCUD_CANFD4"));
        teststep("step", "Start test on ZCUD_CANFD4");
        break;
  case 16:

        setBusContext(getBusNameContext("ZCU_CANFD2"));
        teststep("step", "Start test on ZCU_CANFD2");
        break;
  case 17:

        setBusContext(getBusNameContext("BodyExposedCAN"));
        teststep("step", "Start test on BodyExposedCAN");
        break;

  Default:
        testStepFail("step", "Bus context channel number is wrong!");
  }
}



void getbusbytestchannel(char BusName[],char BusType[],int num)
{
  switch(num)
  {

    case 0:
        strncpy(BusName,"ZCUD_LIN1",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 1:
        strncpy(BusName,"CEM_LIN3",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 2:
        strncpy(BusName,"CEM_LIN2",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 3:
        strncpy(BusName,"CEM_LIN6",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 4:
        strncpy(BusName,"CEM_LIN1",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 5:
        strncpy(BusName,"CEM_LIN4",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 6:
        strncpy(BusName,"ZCUD_LIN2",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 7:
        strncpy(BusName,"ZCUD_LIN3",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 8:
        strncpy(BusName,"CEM_LIN7",elcount(BusName));
        strncpy(BusType,"LIN",elcount(BusType));
        break;
    case 9:
        strncpy(BusName,"PropulsionCAN",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 10:
        strncpy(BusName,"ChassisCAN1",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 11:
        strncpy(BusName,"ZCU_CANFD1",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 12:
        strncpy(BusName,"ZCUD_CANFD3",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 13:
        strncpy(BusName,"ChassisCANFD2",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 14:
        strncpy(BusName,"ZCUD_CAN1",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 15:
        strncpy(BusName,"ZCUD_CANFD4",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 16:
        strncpy(BusName,"ZCU_CANFD2",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    case 17:
        strncpy(BusName,"BodyExposedCAN",elcount(BusName));
        strncpy(BusType,"CAN",elcount(BusType));
        break;
    Default:
        testStepFail("step","Bus context channel number is wrong!");
        break;
  }
}

void CANFD_switch_HighLoad(char souce_network[])
{
    if(strstr(souce_network,"CANFD")>0)
    {
        HighPriority_Msg1.FDF=1;
        LowPriority_Msg1.FDF=1;
    }
    else
    {
        HighPriority_Msg1.FDF=0;
        LowPriority_Msg1.FDF=0;
    }
}
        
void CANFD_switch(char souce_network[])
{
    if(strncmp(souce_network,"CANFD",10)==0)
    {
        temp_message.FDF = 1;
    }
    else
    {
        temp_message.FDF = 0;
    }
}


void Loggingfilenameset(int num, char testcaseid[], char group[], char caseid[], char sub[])
{
    char name[100];
    char network[20];
    switch(num)
    {

    case 0:
        strncpy(network,"ZCUD_LIN1",20);
        break;
    
    case 1:
        strncpy(network,"CEM_LIN3",20);
        break;
    
    case 2:
        strncpy(network,"CEM_LIN2",20);
        break;
    
    case 3:
        strncpy(network,"CEM_LIN6",20);
        break;
    
    case 4:
        strncpy(network,"CEM_LIN1",20);
        break;
    
    case 5:
        strncpy(network,"CEM_LIN4",20);
        break;
    
    case 6:
        strncpy(network,"ZCUD_LIN2",20);
        break;
    
    case 7:
        strncpy(network,"ZCUD_LIN3",20);
        break;
    
    case 8:
        strncpy(network,"CEM_LIN7",20);
        break;
    
    case 9:
        strncpy(network,"PropulsionCAN",20);
        break;
    
    case 10:
        strncpy(network,"ChassisCAN1",20);
        break;
    
    case 11:
        strncpy(network,"ZCU_CANFD1",20);
        break;
    
    case 12:
        strncpy(network,"ZCUD_CANFD3",20);
        break;
    
    case 13:
        strncpy(network,"ChassisCANFD2",20);
        break;
    
    case 14:
        strncpy(network,"ZCUD_CAN1",20);
        break;
    
    case 15:
        strncpy(network,"ZCUD_CANFD4",20);
        break;
    
    case 16:
        strncpy(network,"ZCU_CANFD2",20);
        break;
    
    case 17:
        strncpy(network,"BodyExposedCAN",20);
        break;
    
  Default:
      strncpy(network,"Default",20);
      testStepFail("step","logging channel number is wrong!");
      break;
  }

    strncpy(name,"\\per_testcase\\TC_GW_xx_yy_Vzz_net",100);
    str_replace_regex(name,"TC",testcaseid);
    str_replace_regex(name,"xx",group);
    str_replace_regex(name,"yy",caseid);
    str_replace_regex(name,"zz",sub);
    str_replace_regex(name,"net",network);
    //setLogFileName(name);
    SetLogPath_sig(name, 1);
}

void LIN_Init()
{

    linConfigureResponse(des_DdsZCUD_Lin1Fr01);
    linConfigureResponse(des_AdcZcud_Lin1Fr02);
    linConfigureResponse(des_MdmZCUD_Lin1Fr01);
    linConfigureResponse(des_AdcZcud_Lin1Fr01);
    linConfigureResponse(des_MmdZCUD_Lin1Fr01);
    linConfigureResponse(des_OhcCem_Lin3Fr01);
    linConfigureResponse(des_Srm2Cem_Lin3Fr02);
    linConfigureResponse(des_SigCem_Lin3Fr01);
    linConfigureResponse(des_Srm2Cem_Lin3Fr01);
    linConfigureResponse(des_AwmCem_Lin3Fr01);
    linConfigureResponse(des_OhcCem_Lin3Fr05);
    linConfigureResponse(des_Awm2Cem_Lin3SertNrFr01);
    linConfigureResponse(des_OhcCem_Lin3Fr06);
    linConfigureResponse(des_OhcCem_Lin3Fr04);
    linConfigureResponse(des_OhcCem_Lin3Fr10);
    linConfigureResponse(des_BmsCem_Lin6Fr06);
    linConfigureResponse(des_BmsCem_Lin6Fr10);
    linConfigureResponse(des_BmsCem_Lin6Fr01);
    linConfigureResponse(des_BmsCem_Lin6Fr12);
    linConfigureResponse(des_FmdmCem_Lin6Fr01);
    linConfigureResponse(des_BmsCem_Lin6Fr13);
    linConfigureResponse(des_FdmlCem_Lin6Fr01);
    linConfigureResponse(des_BmsCem_Lin6Fr02);
    linConfigureResponse(des_BmsCem_Lin6Fr16);
    linConfigureResponse(des_BmsCem_Lin6Fr03);
    linConfigureResponse(des_BmsCem_Lin6Fr08);
    linConfigureResponse(des_BmsCem_Lin6Fr11);
    linConfigureResponse(des_BmsCem_Lin6Fr04);
    linConfigureResponse(des_BmsCem_Lin6Fr05);
    linConfigureResponse(des_BmsCem_Lin6Fr09);
    linConfigureResponse(des_BmsCem_Lin6Fr07);
    linConfigureResponse(des_BmsCem_Lin6Fr14);
    linConfigureResponse(des_BmsCem_Lin6Fr15);
    linConfigureResponse(des_BmsCem_Lin6Fr17);
    linConfigureResponse(des_RlsmCem_Lin1Fr02);
    linConfigureResponse(des_RlsmCem_Lin1Fr03);
    linConfigureResponse(des_WmmCem_Lin1Fr01);
    linConfigureResponse(des_RlsmCem_Lin1Fr01);
    linConfigureResponse(des_RlsmCem_Lin1Fr04);
    linConfigureResponse(des_IrmmCem_Lin1Fr01);
    linConfigureResponse(des_IrmmCem_Lin1Fr02);
    linConfigureResponse(des_FtksCem_Lin4Fr01);
    linConfigureResponse(des_LsmCem_Lin4Fr01);
    linConfigureResponse(des_HcmlZcud_Lin2Fr01);
    linConfigureResponse(des_HcmrZcud_Lin2Fr01);
    linConfigureResponse(des_PosmCem_Lin7Fr01);
    linConfigureResponse(des_TCSCem_Lin7Fr03);
    linConfigureResponse(des_TCSCem_Lin7Fr02);
    
}

void messageUpdate(char net_num[], int id, Byte data[])
{
    int k;
    // 按网络通道处理LIN报文数据更新
    if (0) {}  // 用于后续的else if链
    else if (strncmp(net_num, "ZCUD_LIN1", strlen(net_num)) == 0) {
        switch(id) {
            case 0x36:
                for (k = 0; k < des_DdsZCUD_Lin1Fr01.dlc; k++) {
                    des_DdsZCUD_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_DdsZCUD_Lin1Fr01);
                break;
            case 0x39:
                for (k = 0; k < des_AdcZcud_Lin1Fr02.dlc; k++) {
                    des_AdcZcud_Lin1Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_AdcZcud_Lin1Fr02);
                break;
            case 0x13:
                for (k = 0; k < des_MdmZCUD_Lin1Fr01.dlc; k++) {
                    des_MdmZCUD_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_MdmZCUD_Lin1Fr01);
                break;
            case 0x3b:
                for (k = 0; k < des_AdcZcud_Lin1Fr01.dlc; k++) {
                    des_AdcZcud_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_AdcZcud_Lin1Fr01);
                break;
            case 0x1:
                for (k = 0; k < des_MmdZCUD_Lin1Fr01.dlc; k++) {
                    des_MmdZCUD_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_MmdZCUD_Lin1Fr01);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "CEM_LIN3", strlen(net_num)) == 0) {
        switch(id) {
            case 0x20:
                for (k = 0; k < des_OhcCem_Lin3Fr01.dlc; k++) {
                    des_OhcCem_Lin3Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_OhcCem_Lin3Fr01);
                break;
            case 0x23:
                for (k = 0; k < des_Srm2Cem_Lin3Fr02.dlc; k++) {
                    des_Srm2Cem_Lin3Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_Srm2Cem_Lin3Fr02);
                break;
            case 0x8:
                for (k = 0; k < des_SigCem_Lin3Fr01.dlc; k++) {
                    des_SigCem_Lin3Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_SigCem_Lin3Fr01);
                break;
            case 0x11:
                for (k = 0; k < des_Srm2Cem_Lin3Fr01.dlc; k++) {
                    des_Srm2Cem_Lin3Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_Srm2Cem_Lin3Fr01);
                break;
            case 0x1a:
                for (k = 0; k < des_AwmCem_Lin3Fr01.dlc; k++) {
                    des_AwmCem_Lin3Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_AwmCem_Lin3Fr01);
                break;
            case 0x16:
                for (k = 0; k < des_OhcCem_Lin3Fr05.dlc; k++) {
                    des_OhcCem_Lin3Fr05.byte(k) = data[k];
                }
                linUpdateResponse(des_OhcCem_Lin3Fr05);
                break;
            case 0xe:
                for (k = 0; k < des_Awm2Cem_Lin3SertNrFr01.dlc; k++) {
                    des_Awm2Cem_Lin3SertNrFr01.byte(k) = data[k];
                }
                linUpdateResponse(des_Awm2Cem_Lin3SertNrFr01);
                break;
            case 0x1c:
                for (k = 0; k < des_OhcCem_Lin3Fr06.dlc; k++) {
                    des_OhcCem_Lin3Fr06.byte(k) = data[k];
                }
                linUpdateResponse(des_OhcCem_Lin3Fr06);
                break;
            case 0x14:
                for (k = 0; k < des_OhcCem_Lin3Fr04.dlc; k++) {
                    des_OhcCem_Lin3Fr04.byte(k) = data[k];
                }
                linUpdateResponse(des_OhcCem_Lin3Fr04);
                break;
            case 0x6:
                for (k = 0; k < des_OhcCem_Lin3Fr10.dlc; k++) {
                    des_OhcCem_Lin3Fr10.byte(k) = data[k];
                }
                linUpdateResponse(des_OhcCem_Lin3Fr10);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "CEM_LIN6", strlen(net_num)) == 0) {
        switch(id) {
            case 0x28:
                for (k = 0; k < des_BmsCem_Lin6Fr06.dlc; k++) {
                    des_BmsCem_Lin6Fr06.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr06);
                break;
            case 0x20:
                for (k = 0; k < des_BmsCem_Lin6Fr10.dlc; k++) {
                    des_BmsCem_Lin6Fr10.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr10);
                break;
            case 0x2:
                for (k = 0; k < des_BmsCem_Lin6Fr01.dlc; k++) {
                    des_BmsCem_Lin6Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr01);
                break;
            case 0x29:
                for (k = 0; k < des_BmsCem_Lin6Fr12.dlc; k++) {
                    des_BmsCem_Lin6Fr12.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr12);
                break;
            case 0x16:
                for (k = 0; k < des_FmdmCem_Lin6Fr01.dlc; k++) {
                    des_FmdmCem_Lin6Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_FmdmCem_Lin6Fr01);
                break;
            case 0x2a:
                for (k = 0; k < des_BmsCem_Lin6Fr13.dlc; k++) {
                    des_BmsCem_Lin6Fr13.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr13);
                break;
            case 0x18:
                for (k = 0; k < des_FdmlCem_Lin6Fr01.dlc; k++) {
                    des_FdmlCem_Lin6Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_FdmlCem_Lin6Fr01);
                break;
            case 0x3:
                for (k = 0; k < des_BmsCem_Lin6Fr02.dlc; k++) {
                    des_BmsCem_Lin6Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr02);
                break;
            case 0x26:
                for (k = 0; k < des_BmsCem_Lin6Fr16.dlc; k++) {
                    des_BmsCem_Lin6Fr16.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr16);
                break;
            case 0x4:
                for (k = 0; k < des_BmsCem_Lin6Fr03.dlc; k++) {
                    des_BmsCem_Lin6Fr03.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr03);
                break;
            case 0x7:
                for (k = 0; k < des_BmsCem_Lin6Fr08.dlc; k++) {
                    des_BmsCem_Lin6Fr08.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr08);
                break;
            case 0x21:
                for (k = 0; k < des_BmsCem_Lin6Fr11.dlc; k++) {
                    des_BmsCem_Lin6Fr11.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr11);
                break;
            case 0x9:
                for (k = 0; k < des_BmsCem_Lin6Fr04.dlc; k++) {
                    des_BmsCem_Lin6Fr04.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr04);
                break;
            case 0x6:
                for (k = 0; k < des_BmsCem_Lin6Fr05.dlc; k++) {
                    des_BmsCem_Lin6Fr05.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr05);
                break;
            case 0x10:
                for (k = 0; k < des_BmsCem_Lin6Fr09.dlc; k++) {
                    des_BmsCem_Lin6Fr09.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr09);
                break;
            case 0x8:
                for (k = 0; k < des_BmsCem_Lin6Fr07.dlc; k++) {
                    des_BmsCem_Lin6Fr07.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr07);
                break;
            case 0x24:
                for (k = 0; k < des_BmsCem_Lin6Fr14.dlc; k++) {
                    des_BmsCem_Lin6Fr14.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr14);
                break;
            case 0x25:
                for (k = 0; k < des_BmsCem_Lin6Fr15.dlc; k++) {
                    des_BmsCem_Lin6Fr15.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr15);
                break;
            case 0x27:
                for (k = 0; k < des_BmsCem_Lin6Fr17.dlc; k++) {
                    des_BmsCem_Lin6Fr17.byte(k) = data[k];
                }
                linUpdateResponse(des_BmsCem_Lin6Fr17);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "CEM_LIN1", strlen(net_num)) == 0) {
        switch(id) {
            case 0x2c:
                for (k = 0; k < des_RlsmCem_Lin1Fr02.dlc; k++) {
                    des_RlsmCem_Lin1Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_RlsmCem_Lin1Fr02);
                break;
            case 0x2:
                for (k = 0; k < des_RlsmCem_Lin1Fr03.dlc; k++) {
                    des_RlsmCem_Lin1Fr03.byte(k) = data[k];
                }
                linUpdateResponse(des_RlsmCem_Lin1Fr03);
                break;
            case 0x25:
                for (k = 0; k < des_WmmCem_Lin1Fr01.dlc; k++) {
                    des_WmmCem_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_WmmCem_Lin1Fr01);
                break;
            case 0x15:
                for (k = 0; k < des_RlsmCem_Lin1Fr01.dlc; k++) {
                    des_RlsmCem_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_RlsmCem_Lin1Fr01);
                break;
            case 0x3:
                for (k = 0; k < des_RlsmCem_Lin1Fr04.dlc; k++) {
                    des_RlsmCem_Lin1Fr04.byte(k) = data[k];
                }
                linUpdateResponse(des_RlsmCem_Lin1Fr04);
                break;
            case 0x10:
                for (k = 0; k < des_IrmmCem_Lin1Fr01.dlc; k++) {
                    des_IrmmCem_Lin1Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_IrmmCem_Lin1Fr01);
                break;
            case 0x13:
                for (k = 0; k < des_IrmmCem_Lin1Fr02.dlc; k++) {
                    des_IrmmCem_Lin1Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_IrmmCem_Lin1Fr02);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "CEM_LIN4", strlen(net_num)) == 0) {
        switch(id) {
            case 0xc:
                for (k = 0; k < des_FtksCem_Lin4Fr01.dlc; k++) {
                    des_FtksCem_Lin4Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_FtksCem_Lin4Fr01);
                break;
            case 0x20:
                for (k = 0; k < des_LsmCem_Lin4Fr01.dlc; k++) {
                    des_LsmCem_Lin4Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_LsmCem_Lin4Fr01);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "ZCUD_LIN2", strlen(net_num)) == 0) {
        switch(id) {
            case 0x1:
                for (k = 0; k < des_HcmlZcud_Lin2Fr01.dlc; k++) {
                    des_HcmlZcud_Lin2Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_HcmlZcud_Lin2Fr01);
                break;
            case 0x2:
                for (k = 0; k < des_HcmrZcud_Lin2Fr01.dlc; k++) {
                    des_HcmrZcud_Lin2Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_HcmrZcud_Lin2Fr01);
                break;
            default:
                break;
        }
    }
    else if (strncmp(net_num, "CEM_LIN7", strlen(net_num)) == 0) {
        switch(id) {
            case 0x11:
                for (k = 0; k < des_PosmCem_Lin7Fr01.dlc; k++) {
                    des_PosmCem_Lin7Fr01.byte(k) = data[k];
                }
                linUpdateResponse(des_PosmCem_Lin7Fr01);
                break;
            case 0xf:
                for (k = 0; k < des_TCSCem_Lin7Fr03.dlc; k++) {
                    des_TCSCem_Lin7Fr03.byte(k) = data[k];
                }
                linUpdateResponse(des_TCSCem_Lin7Fr03);
                break;
            case 0xa:
                for (k = 0; k < des_TCSCem_Lin7Fr02.dlc; k++) {
                    des_TCSCem_Lin7Fr02.byte(k) = data[k];
                }
                linUpdateResponse(des_TCSCem_Lin7Fr02);
                break;
            default:
                break;
        }
    }
}


on timer SimHighLoadTimer_HighPriority
{
  int burst[network_quantity],busload[network_quantity],testchannel,buschannel,h;
  char busaname[20],bustype[20];
  for(testchannel=0;testchannel<network_quantity;testchannel++)
  {
    getbusbytestchannel(busaname,bustype,testchannel);
    if((strncmp(bustype,"CANFD",strlen("CANFD"))==0)||(strncmp(bustype,"CAN",strlen("CAN"))==0))
    {
      buschannel=GetBusNameContext(busaname);
      CANFD_switch_HighLoad(busaname);
      for(h=0; h<burst[testchannel] ;h++)
      { 

         HighPriority_Msg1.can=buschannel;
         output(HighPriority_Msg1);

      }
      
      busload[testchannel] = canGetBusLoad(buschannel);
      if(busload[testchannel]<80)
        burst[testchannel]++; 
    }      
  }
}

on timer SimHighLoadTimer_LowPriority
{
  int burst[network_quantity],busload[network_quantity],testchannel,buschannel,h;
  char busaname[20],bustype[20];
  for(testchannel=0;testchannel<network_quantity;testchannel++)
  {
    getbusbytestchannel(busaname,bustype,testchannel);
    if((strncmp(bustype,"CANFD",strlen("CANFD"))==0)||(strncmp(bustype,"CAN",strlen("CAN"))==0))
    {
      buschannel=GetBusNameContext(busaname);
      CANFD_switch_HighLoad(busaname);
      for(h=0; h<burst[testchannel] ;h++)
      { 

         LowPriority_Msg1.can=buschannel;
         output(LowPriority_Msg1);

      }
      
      busload[testchannel] = canGetBusLoad(buschannel);
      if(busload[testchannel]<80)
        burst[testchannel]++; 
    }      
  }
}
