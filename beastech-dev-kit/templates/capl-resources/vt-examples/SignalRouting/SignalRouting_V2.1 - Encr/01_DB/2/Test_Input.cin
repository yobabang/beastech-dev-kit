           {   /*sig_name*/"isVFCVectorSASVFCid27_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid44_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid30_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid23_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid7_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid55_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/190,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid21_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid17_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid54_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid29_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid57_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/188,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid56_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/189,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid9_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid18_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid45_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid25_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid12_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid16_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid48_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/181,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid11_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid13_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid24_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid39_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/174,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid19_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid49_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/180,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid53_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid33_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid43_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid41_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/172,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASBlockID_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid8_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid10_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid35_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid58_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid59_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid34_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid40_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/173,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid51_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/178,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid52_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid20_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSASVFCid50_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/179,    /*src_cyc*/101,  /*src_id*/0x567,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isEngEffSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/210,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/208,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatHeatgDesPwrCnsRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x336,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/14,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isTopPosHmiFeedBack_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/12,   /*des_updatebit*/360,      /*initvalue*/0         },
           {   /*sig_name*/"isDenoOfDiagcRateGen_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x171,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/6,   /*des_updatebit*/200,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBrkSysStCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/47,   /*des_updatebit*/178,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBrkSysStBrkSysSt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/47,   /*des_updatebit*/178,      /*initvalue*/0         },
           {   /*sig_name*/"isSecBrkSysStChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x62,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/47,   /*des_updatebit*/178,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtBtnSts2Cntr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofAndCurtBtnSts2Pos_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgTqReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/195,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgTqReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/195,   /*des_updatebit*/169,      /*initvalue*/8188         },
           {   /*sig_name*/"isIsgTqReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/197,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/153,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/195,   /*des_updatebit*/169,      /*initvalue*/3         },
           {   /*sig_name*/"isIsgTqReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/177,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/149,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/195,   /*des_updatebit*/169,      /*initvalue*/0         },
           {   /*sig_name*/"isRowReLeSldAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/53,   /*des_updatebit*/13,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgAvlStsRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x331,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/4,   /*des_updatebit*/408,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapU3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x1fa,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/45,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorWPRLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x572,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isReCurtBtnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/28,   /*src_dlc*/7,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/1000,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlHSWTRaw_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x2e6,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e2, /*src_updatebit*/35,   /*des_updatebit*/368,      /*initvalue*/900         },
           {   /*sig_name*/"isRowSecRiRotSwt2BtnModA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/52,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiRotSwt2BtnModC_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/52,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiRotSwt2BtnModB_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/52,      /*initvalue*/0         },
           {   /*sig_name*/"isMoleculeVlv2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x2eb,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/32,   /*des_updatebit*/242,      /*initvalue*/0         },
           {   /*sig_name*/"isDCMotrCtrlDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/48,   /*des_updatebit*/96,      /*initvalue*/0         },
           {   /*sig_name*/"isRowReLeModSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x165,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/12,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isGrilleRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/16,   /*des_updatebit*/272,      /*initvalue*/0         },
           {   /*sig_name*/"isKickDetnLeReSts_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/24,   /*src_dlc*/1,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/499,      /*initvalue*/0         },
           {   /*sig_name*/"isDmcStsFrntToEscDmcSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/219,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/113,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isDmcStsFrntToEscCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/113,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isDmcStsFrntToEscChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/215,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/113,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isDmcStsFrntToEscDmcActAppTarTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/113,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isDmcStsFrntToEscDmcSWInfo_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/113,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isSunCurtImpctDetnStsSRM2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/300,      /*initvalue*/0         },
           {   /*sig_name*/"isFuLeakDetdActv_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/250,   /*des_id*/0x361, /*src_updatebit*/2,   /*des_updatebit*/234,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbRelsEnaSec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/86,   /*des_updatebit*/160,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorOpenerDrvrReSts2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1,   /*des_updatebit*/323,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngRiReCinFailCinchRestFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/19,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngRiReCinFailCinchFlt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/19,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerStsToCrabMov_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/60,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgOpenPosn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/32,   /*des_updatebit*/486,      /*initvalue*/101         },
           {   /*sig_name*/"isHwRowRearRiMassSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/30,   /*des_updatebit*/424,      /*initvalue*/0         },
           {   /*sig_name*/"isCH12DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/50,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/332,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/321,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/334,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/371,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/350,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/360,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/374,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/349,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/361,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/345,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/329,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/331,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/333,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/337,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/373,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/336,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/324,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/325,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/370,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/340,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/328,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/344,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/322,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorPOTVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x547,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrLiCmdGroupIntrLiRoofDim_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/292,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrLiCmdGroupIntrLiActvn_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/292,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrLiCmdGroupIntrLiRoofDmdOff_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/292,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR1FltStsH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/35,   /*des_updatebit*/355,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR1FltStsR1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/35,   /*des_updatebit*/355,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR1FltStsR2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/35,   /*des_updatebit*/355,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWFltStsR1FltStsH2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x200,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/35,   /*des_updatebit*/355,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatHeatgActlPwrCnsLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/27,   /*des_updatebit*/49,      /*initvalue*/0         },
           {   /*sig_name*/"isSunCurtPosnSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/186,      /*initvalue*/0         },
           {   /*sig_name*/"isCH4DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/57,   /*des_updatebit*/195,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdSeatRiCushFldLckMotSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/58,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isDstToEmptyIndcdDstToEmpty2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/130,   /*des_updatebit*/410,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedDaytiRunngLampWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/216,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrMirrRespIntrMirrIntFailr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrMirrRespResdUInt6_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrMirrRespIntrMirrDimPerc_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isIntrMirrRespResdBoolean_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/16,   /*src_dlc*/4,   /*des_cyc*/70,   /*des_id*/0x25f, /*src_updatebit*/1000,   /*des_updatebit*/8,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngLeReCinFailCinchRestFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/19,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorSldngLeReCinFailCinchFlt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/19,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isBookTrvlFltSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/64,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/130,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isCfgPrmStsOfLeReKickSnsr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/130,    /*src_cyc*/101,  /*src_id*/24,   /*src_dlc*/1,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/1000,   /*des_updatebit*/128,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMUndVoltRangErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/0,   /*des_updatebit*/4,      /*initvalue*/0         },
           {   /*sig_name*/"isPtRotReqAckd2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/51,   /*des_updatebit*/142,      /*initvalue*/0         },
           {   /*sig_name*/"isBattRlyStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/465,      /*initvalue*/0         },
           {   /*sig_name*/"isBattRlyStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/465,      /*initvalue*/0         },
           {   /*sig_name*/"isBattRlyStsPrimSwtSts_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/1000,   /*des_updatebit*/465,      /*initvalue*/1         },
           {   /*sig_name*/"isHiLoBeamLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/24,   /*des_updatebit*/280,      /*initvalue*/0         },
           {   /*sig_name*/"isLRDetctDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x25e,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/2,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isAltFltT_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x48f,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/12,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgObstclDetn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/52,   /*des_updatebit*/479,      /*initvalue*/0         },
           {   /*sig_name*/"isSupply5VErrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x25e,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/15,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeLegRstLenPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/28,   /*des_updatebit*/235,      /*initvalue*/1000         },
           {   /*sig_name*/"isRowSecLeLegRstLenPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/28,   /*des_updatebit*/235,      /*initvalue*/1         },
           {   /*sig_name*/"isHvBattPreChrgReq_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x14f,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/49,   /*des_updatebit*/440,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/157,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1FltDateStoreFlag_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/180,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1SteerErr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/170,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1FiveMinRuleSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/181,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/165,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1HealthSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1FltSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/173,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1SysDegradeReason_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/161,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isPubCANHWASysH1Group1SysDegradeReasonVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/179,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/178,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatVentnAvlStsRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x331,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/0,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgMachFltForEcuDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/2,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/1000,   /*des_updatebit*/162,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenSplyErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/21,   /*des_updatebit*/31,      /*initvalue*/0         },
           {   /*sig_name*/"isMirrSelnReq_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/1000,   /*des_updatebit*/28,      /*initvalue*/0         },
           {   /*sig_name*/"isManSyncnIndcnReqR2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/16,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrBrkLiSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x91,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/15,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSDoorSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/339,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/338,      /*initvalue*/0         },
           {   /*sig_name*/"isADataRawSafeALgt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isADataRawSafeALgt1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/1         },
           {   /*sig_name*/"isADataRawSafeALat_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isADataRawSafeAVert_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/1155         },
           {   /*sig_name*/"isADataRawSafeALat1Qf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/1         },
           {   /*sig_name*/"isADataRawSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/255         },
           {   /*sig_name*/"isADataRawSafeAVertQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/1         },
           {   /*sig_name*/"isADataRawSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x12,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNInp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/455,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNOutp_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/456,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNOutpOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/492,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNInpOk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/493,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/481,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmNChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/473,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/509,   /*des_updatebit*/91,      /*initvalue*/0         },
           {   /*sig_name*/"isGrilleLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/16,   /*des_updatebit*/264,      /*initvalue*/0         },
           {   /*sig_name*/"isStreamingMirrPosn_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/19,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/267,      /*initvalue*/3         },
           {   /*sig_name*/"isMcuOvrTempErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/26,   /*des_updatebit*/237,      /*initvalue*/0         },
           {   /*sig_name*/"isRowReRiModSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/43,   /*des_updatebit*/19,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbStsChgNotifReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/6,   /*des_updatebit*/400,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedHiBeamWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapU4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x1fa,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/44,   /*des_updatebit*/104,      /*initvalue*/0         },
           {   /*sig_name*/"isImobEngSts3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/218,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/700,   /*des_id*/0x40a, /*src_updatebit*/216,   /*des_updatebit*/42,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorDPODVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x543,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isTCSnsrTSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/160,      /*initvalue*/250         },
           {   /*sig_name*/"isBattRAtTNomRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/9,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/416,      /*initvalue*/0         },
           {   /*sig_name*/"isHCMR2DTCGroup4_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/138,      /*initvalue*/0         },
           {   /*sig_name*/"isSwivelMotLeIninSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/4,   /*des_updatebit*/464,      /*initvalue*/0         },
           {   /*sig_name*/"isRelHumSnsrRelHum_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/24,      /*initvalue*/80         },
           {   /*sig_name*/"isRowSecLeEasyInOutRstSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x201,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/36,   /*des_updatebit*/17,      /*initvalue*/0         },
           {   /*sig_name*/"isBattUMinAvgDurgCrkRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/417,      /*initvalue*/0         },
           {   /*sig_name*/"isHoodOpenerPosn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/8,   /*des_updatebit*/368,      /*initvalue*/101         },
           {   /*sig_name*/"isBattIQuiscAvgRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/4,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/358,      /*initvalue*/511         },
           {   /*sig_name*/"isPtGearTar_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/155,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/500,   /*des_updatebit*/331,      /*initvalue*/0         },
           {   /*sig_name*/"isPassMidSeatSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x22f,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/5,   /*des_updatebit*/13,      /*initvalue*/0         },
           {   /*sig_name*/"isReWiprRotyCmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x322, /*src_updatebit*/29,   /*des_updatebit*/146,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedLoBeamWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isPropLgtCtrlModCfmdPropLgtCtrlModCfmd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/69,   /*des_updatebit*/201,      /*initvalue*/0         },
           {   /*sig_name*/"isPropLgtCtrlModCfmdLgtDegradation_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/69,   /*des_updatebit*/201,      /*initvalue*/0         },
           {   /*sig_name*/"isPropLgtCtrlModCfmdChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/69,   /*des_updatebit*/201,      /*initvalue*/0         },
           {   /*sig_name*/"isPropLgtCtrlModCfmdCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x11e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/69,   /*des_updatebit*/201,      /*initvalue*/0         },
           {   /*sig_name*/"isCVCH1DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/43,   /*des_updatebit*/299,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReLeCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/151,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/87,   /*des_updatebit*/353,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReLeDmcSWInfo_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/87,   /*des_updatebit*/353,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReLeDmcActAppTarTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/87,   /*des_updatebit*/353,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReLeDmcSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/147,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/87,   /*des_updatebit*/353,      /*initvalue*/0         },
           {   /*sig_name*/"isMotDynCtrlStsReLeChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/87,   /*des_updatebit*/353,      /*initvalue*/0         },
           {   /*sig_name*/"isCenLockSwt_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/478,      /*initvalue*/0         },
           {   /*sig_name*/"isDstTrvldFromSftyBkp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/21,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x22f,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/30,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isEngPwrNormDes_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/36,   /*des_updatebit*/80,      /*initvalue*/0         },
           {   /*sig_name*/"isLowrTailgOpenerSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/22,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmHardRotReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/137,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/52,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isOxygenTubeBlk_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/36,   /*des_updatebit*/373,      /*initvalue*/0         },
           {   /*sig_name*/"isRWASteerLockWarnIndcn2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/56,   /*des_updatebit*/234,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtMvngSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/48,      /*initvalue*/0         },
           {   /*sig_name*/"isHwSwtRowSecRiEasyInOutForThrd2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/49,   /*des_updatebit*/408,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/51,   /*des_updatebit*/315,      /*initvalue*/1000         },
           {   /*sig_name*/"isRowSecRiSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/51,   /*des_updatebit*/315,      /*initvalue*/1         },
           {   /*sig_name*/"isWPRRSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x217,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/3,   /*des_updatebit*/419,      /*initvalue*/1         },
           {   /*sig_name*/"isPtTqAtWhlFrntActCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtAxleFrntAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlFrntLeAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlsFrntQly_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtWhlFrntActPtTqAtWhlFrntRiAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtWhlFrntActChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/56,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprLvrDiagc_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/63,   /*des_updatebit*/237,      /*initvalue*/3         },
           {   /*sig_name*/"isPressureFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/372,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/35,   /*des_updatebit*/370,      /*initvalue*/0         },
           {   /*sig_name*/"isSunCurtMoveDir2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/178,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorSUMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x565,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4b5, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgEcuIntFailrRowThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x79,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/9,   /*des_updatebit*/306,      /*initvalue*/0         },
           {   /*sig_name*/"isEngPwrCns_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/12,   /*des_updatebit*/76,      /*initvalue*/0         },
           {   /*sig_name*/"isADC6DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/28,   /*des_updatebit*/364,      /*initvalue*/0         },
           {   /*sig_name*/"isGearMovmtFlg_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/37,   /*des_updatebit*/105,      /*initvalue*/0         },
           {   /*sig_name*/"isFrontCrossRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/256,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerColRatGroupH1RatMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/51,   /*des_updatebit*/19,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerColRatGroupH1SteerRatVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/51,   /*des_updatebit*/19,      /*initvalue*/0         },
           {   /*sig_name*/"isWinWshrLvrCmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/50,   /*des_updatebit*/229,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdLeMassgSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x7a,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/40,   /*des_updatebit*/64,      /*initvalue*/0         },
           {   /*sig_name*/"isRestrntSysLampReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/50,   /*des_updatebit*/434,      /*initvalue*/0         },
           {   /*sig_name*/"isBoostBuckErrDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/33,   /*des_updatebit*/81,      /*initvalue*/0         },
           {   /*sig_name*/"isHCML2DTCGroup4_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/120,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh12Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/242,      /*initvalue*/0         },
           {   /*sig_name*/"isWhlMotSysRiTqAvlTqAvlMin_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/145,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/163,   /*des_updatebit*/470,      /*initvalue*/8188         },
           {   /*sig_name*/"isWhlMotSysRiTqAvlTqAvlMax_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/163,   /*des_updatebit*/470,      /*initvalue*/8188         },
           {   /*sig_name*/"isDoorSldngRiReWarnSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/54,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntFogLampWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/248,      /*initvalue*/0         },
           {   /*sig_name*/"isAdjSpdLimnWarn_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/386,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/384,   /*des_updatebit*/507,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/496,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/498,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/488,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/502,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/492,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/472,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/511,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/452,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/465,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/510,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/499,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/506,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/507,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/504,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/466,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/486,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/481,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/467,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/505,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/501,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/473,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/494,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/508,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/500,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/450,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/464,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/480,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/484,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/489,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorCMDVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/485,    /*src_cyc*/101,  /*src_id*/0x548,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgLvlStsRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x342,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/53,   /*des_updatebit*/360,      /*initvalue*/0         },
           {   /*sig_name*/"isHybErrIndcnReqTelltlSysHybFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/220,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/219,   /*des_updatebit*/211,      /*initvalue*/0         },
           {   /*sig_name*/"isHybErrIndcnReqTelltlElecDrvFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/221,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/219,   /*des_updatebit*/211,      /*initvalue*/0         },
           {   /*sig_name*/"isHybErrIndcnReqTelltlBattTracCutOff_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/219,   /*des_updatebit*/211,      /*initvalue*/0         },
           {   /*sig_name*/"isHybErrIndcnReqTelltlBattTracFailr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/222,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/219,   /*des_updatebit*/211,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiSideSldPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/50,   /*des_updatebit*/299,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiSideSldPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x219,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/50,   /*des_updatebit*/299,      /*initvalue*/0         },
           {   /*sig_name*/"isEngAmbTCalcd_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/369,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/70,   /*des_updatebit*/376,      /*initvalue*/120         },
           {   /*sig_name*/"isIsgSpdActSgnSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/479,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/473,   /*des_updatebit*/57,      /*initvalue*/1         },
           {   /*sig_name*/"isIsgSpdActSgnSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/471,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/473,   /*des_updatebit*/57,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgSpdActSgnSafeIsgSpdActSgn800_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/455,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/473,   /*des_updatebit*/57,      /*initvalue*/20000         },
           {   /*sig_name*/"isIsgSpdActSgnSafeQF_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/475,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/473,   /*des_updatebit*/57,      /*initvalue*/0         },
           {   /*sig_name*/"isEngNSafeEngNGrdt_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/51,   /*des_updatebit*/108,      /*initvalue*/0         },
           {   /*sig_name*/"isEngNSafeEngN_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/51,   /*des_updatebit*/108,      /*initvalue*/0         },
           {   /*sig_name*/"isEngNSafeEngNCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/51,   /*des_updatebit*/108,      /*initvalue*/0         },
           {   /*sig_name*/"isEngNSafeEngNChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/51,   /*des_updatebit*/108,      /*initvalue*/0         },
           {   /*sig_name*/"isHoodOpenerSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/0x205,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/19,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isADC3DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/8,   /*des_updatebit*/340,      /*initvalue*/0         },
           {   /*sig_name*/"isHWAColAgMaxH1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/40,   /*des_updatebit*/312,      /*initvalue*/0         },
           {   /*sig_name*/"isBackflushVlvErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/29,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isIDcDcActLoSideChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/147,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/20,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isIDcDcActLoSideCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/20,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isIDcDcActLoSideIDcDcActLoSide_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x149,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/20,   /*des_updatebit*/368,      /*initvalue*/0         },
           {   /*sig_name*/"isHWA1EgyCnsGroupIVal_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/29,   /*des_updatebit*/225,      /*initvalue*/2500         },
           {   /*sig_name*/"isHWA1EgyCnsGroupUval_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x211,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/29,   /*des_updatebit*/225,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsIntHighVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsOutOpenCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsIntLowVolt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsECUFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsOutOverCircuit_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsLoadErr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isDimRoofFailrStsResvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/88,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMidLumPosPercDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/456,      /*initvalue*/0         },
           {   /*sig_name*/"isBattCycChrgCntrRaw_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/3,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgLvlStsRowSecRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/5,   /*des_updatebit*/344,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeLegRstHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/12,   /*des_updatebit*/219,      /*initvalue*/1         },
           {   /*sig_name*/"isRowSecLeLegRstHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/12,   /*des_updatebit*/219,      /*initvalue*/1000         },
           {   /*sig_name*/"isRowSecLeInclPosAngle_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x24b,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/13,   /*des_updatebit*/136,      /*initvalue*/0         },
           {   /*sig_name*/"isBattTLiCellBattTCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/497,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/504,      /*initvalue*/256         },
           {   /*sig_name*/"isBattTLiCellBattTCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/504,      /*initvalue*/256         },
           {   /*sig_name*/"isBattTLiCellBattTCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/8,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/1000,   /*des_updatebit*/504,      /*initvalue*/256         },
           {   /*sig_name*/"isRowSecRiHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/493,    /*src_cyc*/101,  /*src_id*/0x166,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/47,   /*des_updatebit*/491,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x166,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/47,   /*des_updatebit*/491,      /*initvalue*/1000         },
           {   /*sig_name*/"isChdPrtnRightSwReq_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/458,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHSWTRawThrdLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/8,   /*des_updatebit*/132,      /*initvalue*/900         },
           {   /*sig_name*/"isOxygenGenrErrInfo_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/11,   /*des_updatebit*/0,      /*initvalue*/0         },
           {   /*sig_name*/"isReSunCurtMoveDir2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/66,      /*initvalue*/0         },
           {   /*sig_name*/"isDoorDrvrHldExitRmm2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x1d0,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/2,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtPassMidBltLockEquid_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/24,   /*des_updatebit*/220,      /*initvalue*/1         },
           {   /*sig_name*/"isBltLockStAtPassMidBltLockSt1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/24,   /*des_updatebit*/220,      /*initvalue*/0         },
           {   /*sig_name*/"isBltLockStAtPassMidBltLockSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/24,   /*des_updatebit*/220,      /*initvalue*/1         },
           {   /*sig_name*/"isHvBattSocEngStart_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sig_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/180,   /*des_updatebit*/204,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatVentnActlPwrCnsLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/36,   /*des_updatebit*/189,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMSwVers_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x2eb,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/38,   /*des_updatebit*/185,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctVehOri_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/4         },
           {   /*sig_name*/"isRecOfImpctImpctRollAg_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashOffroadA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashOffroadRTsevere_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashSideRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctImpctDvy_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashState_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashFrnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashSideLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashRollovr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashRe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashOffroadD_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashOffroadRT_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctCrashPed_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isRecOfImpctImpctDvx_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/33,   /*des_updatebit*/182,      /*initvalue*/0         },
           {   /*sig_name*/"isMirrActvBtn_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/54,   /*src_dlc*/7,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/1000,   /*des_updatebit*/134,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowRearRiMassSwtStck_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x21c,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/54,   /*des_updatebit*/432,      /*initvalue*/0         },
           {   /*sig_name*/"isPedProtnMsgReqForFlt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/51,   /*des_updatebit*/437,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowLeVentnAutoSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/0x155,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/22,   /*des_updatebit*/471,      /*initvalue*/0         },
           {   /*sig_name*/"isLMMCommDTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x259,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/41,   /*des_updatebit*/144,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrFogLiSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/16,   /*des_updatebit*/224,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiVentnAutoSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x151,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x170, /*src_updatebit*/22,   /*des_updatebit*/417,      /*initvalue*/0         },
           {   /*sig_name*/"isBusCurrentFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x2d0,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/23,   /*des_updatebit*/16,      /*initvalue*/0         },
           {   /*sig_name*/"isIuprDenominatorInhb_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/210,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/209,   /*des_updatebit*/456,      /*initvalue*/0         },
           {   /*sig_name*/"isPassElecRunngBdSts_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/184,      /*initvalue*/0         },
           {   /*sig_name*/"isCH1DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x255,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/51,   /*des_updatebit*/147,      /*initvalue*/0         },
           {   /*sig_name*/"isTILePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/1,   /*des_updatebit*/329,      /*initvalue*/0         },
           {   /*sig_name*/"isADC1DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/0,   /*des_updatebit*/324,      /*initvalue*/0         },
           {   /*sig_name*/"isPtCluTqCpReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/21,   /*des_updatebit*/173,      /*initvalue*/0         },
           {   /*sig_name*/"isPtCluTqCpReq1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/21,   /*des_updatebit*/173,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMCmprSpdFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x2d4,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/9,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isCH6DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/59,   /*des_updatebit*/235,      /*initvalue*/0         },
           {   /*sig_name*/"isBattIShrtAvb_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/1000,   /*des_id*/0x4c3, /*src_updatebit*/1000,   /*des_updatebit*/280,      /*initvalue*/32768         },
           {   /*sig_name*/"isTrlrLampChkSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/23,   /*des_updatebit*/372,      /*initvalue*/0         },
           {   /*sig_name*/"isThermFctReq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/233,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/232,   /*des_updatebit*/354,      /*initvalue*/0         },
           {   /*sig_name*/"isRowThrdRiInclAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/45,   /*des_updatebit*/77,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnBrkTqToTQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/339,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/337,   /*des_updatebit*/89,      /*initvalue*/3         },
           {   /*sig_name*/"isPrpsnBrkTqToTChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/335,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/337,   /*des_updatebit*/89,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnBrkTqToTCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/343,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/337,   /*des_updatebit*/89,      /*initvalue*/0         },
           {   /*sig_name*/"isPrpsnBrkTqToTTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/319,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/337,   /*des_updatebit*/89,      /*initvalue*/0         },
           {   /*sig_name*/"isHwRowThrdRiFldRsdSwtSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x207,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/24,   /*des_updatebit*/264,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbApplyEnaSec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/77,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/509,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/76,   /*des_updatebit*/472,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatMassgBackBlstrFailrDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/192,      /*initvalue*/0         },
           {   /*sig_name*/"isDstToEmptyIndcdDstToEmpty1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/114,   /*des_updatebit*/394,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatHeatgAvlStsRowThrdRi_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x329,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e3, /*src_updatebit*/4,   /*des_updatebit*/420,      /*initvalue*/0         },
           {   /*sig_name*/"isSafetyCrashFb_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x360,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/48,   /*des_updatebit*/321,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowThrdRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/48,   /*des_updatebit*/344,      /*initvalue*/1         },
           {   /*sig_name*/"isRowThrdLeFldRsdSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/42,   /*des_updatebit*/61,      /*initvalue*/0         },
           {   /*sig_name*/"isLevelMotRiIninSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/0x252,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/6,   /*des_updatebit*/153,      /*initvalue*/0         },
           {   /*sig_name*/"isPtTqAtAxleAvlFrntMax_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4ee, /*src_updatebit*/502,   /*des_updatebit*/338,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofImpctDetnStsSRM2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/296,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmErrIndcnReq2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x1e0,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/6,   /*des_updatebit*/304,      /*initvalue*/0         },
           {   /*sig_name*/"isPtVehSpdMaxChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/27,   /*des_updatebit*/83,      /*initvalue*/0         },
           {   /*sig_name*/"isPtVehSpdMaxReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/27,   /*des_updatebit*/83,      /*initvalue*/250         },
           {   /*sig_name*/"isPtVehSpdMaxCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x129,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/27,   /*des_updatebit*/83,      /*initvalue*/0         },
           {   /*sig_name*/"isDPAModStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/8,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isDPAModStsDPAModSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/8,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isDPAModStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x5b,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/8,   /*des_updatebit*/480,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdSeatRiPosCalResp_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x207,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/38,   /*des_updatebit*/364,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbLampReqPassAirbLampEnaReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/33,   /*des_updatebit*/134,      /*initvalue*/2         },
           {   /*sig_name*/"isPassAirbLampReqChgOfPassAirbSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/33,   /*des_updatebit*/134,      /*initvalue*/0         },
           {   /*sig_name*/"isPassAirbLampReqChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/33,   /*des_updatebit*/134,      /*initvalue*/255         },
           {   /*sig_name*/"isPassAirbLampReqPassAirbLampDiReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/33,   /*des_updatebit*/134,      /*initvalue*/2         },
           {   /*sig_name*/"isPassAirbLampReqCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/33,   /*des_updatebit*/134,      /*initvalue*/0         },
           {   /*sig_name*/"isCH7DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/60,   /*des_updatebit*/251,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrpedlStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/57,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrpedlStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/57,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrpedlStsFltSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x1c7,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/57,   /*des_updatebit*/202,      /*initvalue*/0         },
           {   /*sig_name*/"isHSD2DTCLeSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x251,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/52,   /*des_updatebit*/380,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrLampActvtChk_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/8,   /*des_updatebit*/378,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/353,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/352,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/362,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/358,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/356,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/363,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/354,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/355,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapMosStsBoolean9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x1f0,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/16,   /*des_updatebit*/361,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowFrthLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x225,   /*src_dlc*/8,   /*des_cyc*/200,   /*des_id*/0x331, /*src_updatebit*/30,   /*des_updatebit*/274,      /*initvalue*/0         },
           {   /*sig_name*/"isCH3DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/56,   /*des_updatebit*/187,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntAutoDrvMkrLampWithLINLe_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/232,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrRiIndcrFltSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/9,   /*des_updatebit*/386,      /*initvalue*/0         },
           {   /*sig_name*/"isCVCH2DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x25a,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/51,   /*des_updatebit*/315,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh4Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x105,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/90,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh6Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x106,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/9,   /*des_updatebit*/194,      /*initvalue*/0         },
           {   /*sig_name*/"isFrntSunCurtMvngSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_cyc*/40,   /*des_id*/0x180, /*src_updatebit*/1000,   /*des_updatebit*/17,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqH1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/16,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqH1SteerErrReq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/171,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/16,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isSBWErrReqH1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x2c2,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/16,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh10Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/138,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerAstLvl_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3d0, /*src_updatebit*/16,   /*des_updatebit*/284,      /*initvalue*/0         },
           {   /*sig_name*/"isTrObstclDetn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x95,   /*src_dlc*/8,   /*des_cyc*/300,   /*des_id*/0x371, /*src_updatebit*/11,   /*des_updatebit*/25,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfLeCh12Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x103,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/8,   /*des_updatebit*/154,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData5_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData7_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataACnt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isBMS2FltStsADataAData6_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/41,   /*src_dlc*/8,   /*des_cyc*/450,   /*des_id*/0x3b5, /*src_updatebit*/1000,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isSftyAirbRollovrSuppSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x142,   /*src_dlc*/8,   /*des_cyc*/300,   /*des_id*/0x371, /*src_updatebit*/7,   /*des_updatebit*/24,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngdoorRiReAntiPnchFaultPinchEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/16,   /*des_updatebit*/104,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngdoorRiReAntiPnchFaultFltMovngEvnt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_cyc*/350,   /*des_id*/0x390, /*src_updatebit*/16,   /*des_updatebit*/104,      /*initvalue*/0         },
           {   /*sig_name*/"isSuperCapU1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x1fa,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/47,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMHwVers_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x2eb,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/39,   /*des_updatebit*/152,      /*initvalue*/0         },
           {   /*sig_name*/"isStsOfLedFrntAutoDrvMkrLampWithLINRi_0",   /*src_can*/"ZCUD_LIN2",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/2,   /*src_dlc*/7,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/1000,   /*des_updatebit*/240,      /*initvalue*/0         },
           {   /*sig_name*/"isTankTurnModStsChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/319,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/426,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isTankTurnModStsTankTurnModSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/323,   /*sig_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/347,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/426,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isTankTurnModStsCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/327,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0xce,   /*src_dlc*/64,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/426,   /*des_updatebit*/466,      /*initvalue*/0         },
           {   /*sig_name*/"isPressureSnsrErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x2da,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2d1, /*src_updatebit*/34,   /*des_updatebit*/400,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/392,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/403,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/434,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/395,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/441,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/426,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/393,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/422,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/402,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/420,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/432,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/425,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/446,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/438,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/433,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/442,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/400,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/445,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/419,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/440,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/411,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/418,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/414,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/423,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/397,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/396,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorTRMVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/443,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isEpbDrvrDispSec_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/75,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/0x68,   /*src_dlc*/64,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/64,   /*des_updatebit*/459,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatOccptAtRowThrdLeSnsSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x100,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/45,   /*des_updatebit*/85,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/413,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsExtFctLowerLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsExtFctRateLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsExtSafeLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/429,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsExtFctUpperLimActive_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/430,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsDrvrSteerOvrd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/417,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/421,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsLatAgReqNotInRange_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/428,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerExtFctStsLatCtrlReqNotInRange_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/427,    /*src_cyc*/101,  /*src_id*/0x1bc,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/20,   /*des_updatebit*/426,      /*initvalue*/0         },
           {   /*sig_name*/"isHudSnsrErrSnsrErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/1000,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isHudSnsrErrParChk_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/170,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/1000,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isChrgnOrDisChrgnStsFb_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/357,    /*src_cyc*/101,  /*src_id*/0x20e,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/202,   /*des_updatebit*/352,      /*initvalue*/0         },
           {   /*sig_name*/"isSupplyInptDTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x25f,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/12,   /*des_updatebit*/493,      /*initvalue*/0         },
           {   /*sig_name*/"isIntFailrOfLeReKickSnsr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/24,   /*src_dlc*/1,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/1000,   /*des_updatebit*/502,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndDisSldngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndEndNotSuccssWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/380,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndStpDurngMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/376,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndPreConNotFulfil_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/377,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndDurngDoorMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/381,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndStrMovngWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndFltAndPitchWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/379,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndDriveOpnDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/382,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSldngLeReWarnIndFltngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/378,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_cyc*/20,   /*des_id*/0x132, /*src_updatebit*/23,   /*des_updatebit*/460,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowSeatVentnDesPwrCnsRi2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/24,   /*des_updatebit*/473,      /*initvalue*/0         },
           {   /*sig_name*/"isTrsmGearNotAvlSts2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x80,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x4c6, /*src_updatebit*/8,   /*des_updatebit*/299,      /*initvalue*/0         },
           {   /*sig_name*/"isOGMOvrVoltRangErr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x381,   /*src_dlc*/8,   /*des_cyc*/400,   /*des_id*/0x380, /*src_updatebit*/4,   /*des_updatebit*/6,      /*initvalue*/0         },
           {   /*sig_name*/"isLiExtSwtLiExtFctQf_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/437,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/1         },
           {   /*sig_name*/"isLiExtSwtLiExtFctCntr_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/439,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/0         },
           {   /*sig_name*/"isLiExtSwtLiExtFctReq1_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/435,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/3         },
           {   /*sig_name*/"isLiExtSwtLiExtFctCrc_0",   /*src_can*/"CEM_LIN4",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/5,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/1000,   /*des_updatebit*/433,      /*initvalue*/0         },
           {   /*sig_name*/"isOnBdChrgrSt_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x216,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e5, /*src_updatebit*/6,   /*des_updatebit*/339,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeRotSwt2BtnModC_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeRotSwt2BtnModB_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecLeRotSwt2BtnModA_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x21d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/41,   /*des_updatebit*/36,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlLnrChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/168,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/43,   /*des_updatebit*/188,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlLnrCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/176,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/43,   /*des_updatebit*/188,      /*initvalue*/0         },
           {   /*sig_name*/"isAccrPedlLnrAccrPedlRat_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/43,   /*des_updatebit*/188,      /*initvalue*/0         },
           {   /*sig_name*/"isFctOfRiCh11Indcn_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x104,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/9,   /*des_updatebit*/234,      /*initvalue*/0         },
           {   /*sig_name*/"isPOSRiPixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x102,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/57,   /*des_updatebit*/56,      /*initvalue*/0         },
           {   /*sig_name*/"isSunRoofTiltSts2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/490,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/1000,   /*des_updatebit*/489,      /*initvalue*/0         },
           {   /*sig_name*/"isWiprInWipgArFromWMM_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/37,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/350,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatUpLumPosPercDrvr_0",   /*src_can*/"ZCUD_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/1,   /*src_dlc*/4,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/472,      /*initvalue*/0         },
           {   /*sig_name*/"isSwtAhbcReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/503,    /*src_cyc*/101,  /*src_id*/0x2e5,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/27,   /*des_updatebit*/502,      /*initvalue*/0         },
           {   /*sig_name*/"isHwSeatRowSecRiInclHallEna_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/444,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/57,   /*des_updatebit*/443,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowRiHeatgAutoSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x151,   /*src_dlc*/8,   /*des_cyc*/100,   /*des_id*/0x2e0, /*src_updatebit*/23,   /*des_updatebit*/221,      /*initvalue*/0         },
           {   /*sig_name*/"isDRLLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sig_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/49,   /*des_updatebit*/49,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsSecondRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/165,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsSecondRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/164,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsThirdRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/162,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsFirstRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsThirdRowLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/163,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isReadLiErrStsReadLiStsFirstRowRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/166,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/161,      /*initvalue*/0         },
           {   /*sig_name*/"isPtCoolgPostRunActv_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x287,   /*src_dlc*/64,   /*des_cyc*/1000,   /*des_id*/0x4d1, /*src_updatebit*/80,   /*des_updatebit*/347,      /*initvalue*/0         },
           {   /*sig_name*/"isCH9DTCRiSts_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x256,   /*src_dlc*/8,   /*des_cyc*/150,   /*des_id*/0x323, /*src_updatebit*/62,   /*des_updatebit*/283,      /*initvalue*/0         },
