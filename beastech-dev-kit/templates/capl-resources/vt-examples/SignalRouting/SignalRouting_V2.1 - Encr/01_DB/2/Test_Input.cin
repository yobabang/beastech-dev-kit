           {   /*sig_name*/"isVFCVectorOGMVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isVFCVectorOGMVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x542,   /*src_dlc*/8,   /*des_cyc*/1000,   /*des_id*/0x489, /*src_updatebit*/1000,   /*des_updatebit*/1000,      /*initvalue*/0         },
           {   /*sig_name*/"isRowSecRiLegRstLenPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sig_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/28,   /*des_updatebit*/283,      /*initvalue*/1000         },
           {   /*sig_name*/"isRowSecRiLegRstLenPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/28,   /*des_updatebit*/283,      /*initvalue*/1         },
           {   /*sig_name*/"isRowReRiInclAdjmtSwt_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x7d,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x141, /*src_updatebit*/36,   /*des_updatebit*/10,      /*initvalue*/0         },
           {   /*sig_name*/"isSeatRowThrdRiMassgRunng_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/453,    /*src_cyc*/101,  /*src_id*/0x342,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1c5, /*src_updatebit*/60,   /*des_updatebit*/452,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqFrntRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/147,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqReLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqReRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqReLeCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqFrntLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/143,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqFrntLeCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqReRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/171,   /*sig_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqFrntRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqReLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqReRiCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/205,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqWhlVAgrMinReqFrntLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sig_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isTVCBrkTqReqFrntRiCtrlMod_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/193,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_cyc*/50,   /*des_id*/0x1cf, /*src_updatebit*/203,   /*des_updatebit*/131,      /*initvalue*/0         },
           {   /*sig_name*/"isSecRowRiHeatgAutoSts2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/8,   /*des_cyc*/60,   /*des_id*/0x220, /*src_updatebit*/31,   /*des_updatebit*/429,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsrErrRainDetnErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsrErrCalErrActv_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsrErrCalErr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isRainSnsrErrRainDetnErrActv_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/21,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/243,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlCrsSwtAPABtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtSetBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtSetAndCnclBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlCrsSwtResuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlCrsSwtRiBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/141,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtCnclBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlCrsSwtCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtUpBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtTimeGapBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/139,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtDwnBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtReserveBtn2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isSteerWhlCrsSwtUpAndResuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/131,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/1         },
           {   /*sig_name*/"isSteerWhlCrsSwtLeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/128,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_cyc*/30,   /*des_id*/0x80, /*src_updatebit*/25,   /*des_updatebit*/137,      /*initvalue*/0         },
           {   /*sig_name*/"isDRLAndPosLePixelQnty_0",   /*src_can*/"BodyExposedCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sig_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x101,   /*src_dlc*/8,   /*des_cyc*/Event,   /*des_id*/0x53, /*src_updatebit*/0,   /*des_updatebit*/32,      /*initvalue*/0         },
           {   /*sig_name*/"isTrlrSrvReq_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0xd0,   /*src_dlc*/4,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/19,   /*des_updatebit*/398,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgTqActChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/357,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/304,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgTqActIsgTqAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/339,   /*sig_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/304,   /*des_updatebit*/168,      /*initvalue*/8188         },
           {   /*sig_name*/"isIsgTqActCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/365,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/304,   /*des_updatebit*/168,      /*initvalue*/0         },
           {   /*sig_name*/"isIsgTqActQualityFactor_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/361,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_cyc*/10,   /*des_id*/0x5a, /*src_updatebit*/304,   /*des_updatebit*/168,      /*initvalue*/1         },
           {   /*sig_name*/"isTCSModSwtSts2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sig_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/10,   /*src_dlc*/8,   /*des_cyc*/50,   /*des_id*/0x1e5, /*src_updatebit*/1000,   /*des_updatebit*/256,      /*initvalue*/0         },
           {   /*sig_name*/"isCrashStsSafeChks_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/5,   /*des_updatebit*/154,      /*initvalue*/255         },
           {   /*sig_name*/"isCrashStsSafeSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sig_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/5,   /*des_updatebit*/154,      /*initvalue*/0         },
           {   /*sig_name*/"isCrashStsSafeCntr_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sig_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x10,   /*src_dlc*/4,   /*des_cyc*/Event,   /*des_id*/0x43, /*src_updatebit*/5,   /*des_updatebit*/154,      /*initvalue*/0         },
           {   /*sig_name*/"isThrdRowSeatVentnDesPwrCnsLe_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sig_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x208,   /*src_dlc*/8,   /*des_cyc*/80,   /*des_id*/0x281, /*src_updatebit*/35,   /*des_updatebit*/403,      /*initvalue*/0         }
       }
   },
   {
       /*des_can*/ "BodyExposedCAN",
       /*networktype*/ "CAN",
       0,
       {
           0
       }
   }
};

  struct gSignalG{
//    int num[1000];
    char sigGroup_s[1000];
    char sig_name[1000];
    char scr_can[1000];
    char scr_network_type[1000];
    int scr_slotid_fr;
    int scr_basecycle_fr;
    int scr_repetition_fr;
    int scr_startbit;
    int sigG_length;
    int des_slotid_fr;
    int des_basecycle_fr;
    int des_repetition_fr;
    int des_startbit;
    int scr_cyc;
    int scr_id;
    int scr_dlc;
    int des_id;  
    int updatebit_S;
    int updatebit_D;
  };
    
 //data for Signal group routing test
  struct SignalGroup{ 
    char des_can[20]; 
    char des_networktype[20];
    int sum;
    struct gSignalG GSignalG[2500];
  };
  
  struct SignalGroup test_sigG[network_quantity]={
    
       {
       /*des_can*/ "ZCUD_LIN1",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN3",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN2",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN6",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN1",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN4",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "ZCUD_LIN2",
       /*networktype*/ "LIN",
       3,
       {
           {   /*sigGroup_s*/"igLvlgSwtSetReq_0",   /*sig_name*/"isLvlgSwtSetReqLvlgSwtSetReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/195,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/4, /*updatebit_S*/192,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igLvlgSwtSetReq_0",   /*sig_name*/"isLvlgSwtSetReqChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/191,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/4, /*updatebit_S*/192,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igLvlgSwtSetReq_0",   /*sig_name*/"isLvlgSwtSetReqCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/4, /*updatebit_S*/192,   /*updatebit_D*/1000         }
       }
   },
   {
       /*des_can*/ "ZCUD_LIN3",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "CEM_LIN7",
       /*networktype*/ "LIN",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "PropulsionCAN",
       /*networktype*/ "CAN",
       7,
       {
           {   /*sigGroup_s*/"igSecBattSoc_0",   /*sig_name*/"isSecBattSocSoc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/303,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x19d, /*updatebit_S*/313,   /*updatebit_D*/38         },
           {   /*sigGroup_s*/"igSecBattSoc_0",   /*sig_name*/"isSecBattSocChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/309,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x19d, /*updatebit_S*/313,   /*updatebit_D*/38         },
           {   /*sigGroup_s*/"igSecBattSoc_0",   /*sig_name*/"isSecBattSocCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/317,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x19d, /*updatebit_S*/313,   /*updatebit_D*/38         },
           {   /*sigGroup_s*/"igAmbTEstimd_0",   /*sig_name*/"isAmbTEstimdAmbTEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_id*/0x160, /*updatebit_S*/128,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igAmbTEstimd_0",   /*sig_name*/"isAmbTEstimdQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_id*/0x160, /*updatebit_S*/128,   /*updatebit_D*/59         },
           {   /*sigGroup_s*/"igCmptmtAirTEstimdExtd_0",   /*sig_name*/"isCmptmtAirTEstimdExtdComptmtT_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x162, /*updatebit_S*/90,   /*updatebit_D*/58         },
           {   /*sigGroup_s*/"igCmptmtAirTEstimdExtd_0",   /*sig_name*/"isCmptmtAirTEstimdExtdQlyFlg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x162, /*updatebit_S*/90,   /*updatebit_D*/58         }
       }
   },
   {
       /*des_can*/ "ChassisCAN1",
       /*networktype*/ "CAN",
       12,
       {
           {   /*sigGroup_s*/"igSecULoWarnLvPwrErr_0",   /*sig_name*/"isSecULoWarnLvPwrErrULoWarn_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/399,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x171, /*updatebit_S*/318,   /*updatebit_D*/42         },
           {   /*sigGroup_s*/"igSecULoWarnLvPwrErr_0",   /*sig_name*/"isSecULoWarnLvPwrErrLVPwrSplyErrSts_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/387,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x171, /*updatebit_S*/318,   /*updatebit_D*/42         },
           {   /*sigGroup_s*/"igSecULoWarnLvPwrErr_0",   /*sig_name*/"isSecULoWarnLvPwrErrCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x171, /*updatebit_S*/318,   /*updatebit_D*/42         },
           {   /*sigGroup_s*/"igSecULoWarnLvPwrErr_0",   /*sig_name*/"isSecULoWarnLvPwrErrChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x171, /*updatebit_S*/318,   /*updatebit_D*/42         },
           {   /*sigGroup_s*/"igISecDcDcActLoSide_0",   /*sig_name*/"isISecDcDcActLoSideIDcDcActLoSide_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/263,   /*sigG_length*/12,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x169, /*updatebit_S*/1,   /*updatebit_D*/47         },
           {   /*sigGroup_s*/"igISecDcDcActLoSide_0",   /*sig_name*/"isISecDcDcActLoSideCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/275,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x169, /*updatebit_S*/1,   /*updatebit_D*/47         },
           {   /*sigGroup_s*/"igISecDcDcActLoSide_0",   /*sig_name*/"isISecDcDcActLoSideChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/267,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x1ce,   /*src_dlc*/64,   /*des_id*/0x169, /*updatebit_S*/1,   /*updatebit_D*/47         },
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgPen_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/494,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x463, /*updatebit_S*/120,   /*updatebit_D*/51         },
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgSteerMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/503,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x463, /*updatebit_S*/120,   /*updatebit_D*/51         },
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgSteerAsscLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/490,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x463, /*updatebit_S*/120,   /*updatebit_D*/51         },
           {   /*sigGroup_s*/"igCmptmtAirTEstimdExtd_0",   /*sig_name*/"isCmptmtAirTEstimdExtdComptmtT_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/87,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x360, /*updatebit_S*/90,   /*updatebit_D*/42         },
           {   /*sigGroup_s*/"igCmptmtAirTEstimdExtd_0",   /*sig_name*/"isCmptmtAirTEstimdExtdQlyFlg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x360, /*updatebit_S*/90,   /*updatebit_D*/42         }
       }
   },
   {
       /*des_can*/ "ZCU_CANFD1",
       /*networktype*/ "CANFD",
       0,
       {
           0
       }
   },
   {
       /*des_can*/ "ZCUD_CANFD3",
       /*networktype*/ "CANFD",
       3,
       {
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgPen_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/494,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x153, /*updatebit_S*/120,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgSteerMod_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/503,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x153, /*updatebit_S*/120,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igSteerSetg_0",   /*sig_name*/"isSteerSetgSteerAsscLvl_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/490,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x2c5,   /*src_dlc*/64,   /*des_id*/0x153, /*updatebit_S*/120,   /*updatebit_D*/80         }
       }
   },
   {
       /*des_can*/ "ChassisCANFD2",
       /*networktype*/ "CANFD",
       23,
       {
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRControlPoint_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/410,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRMessageType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRRetransmission_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/409,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLROffset_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRCyclicCounter_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/412,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRUpdate_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/408,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRValue_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/32,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRPathIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/394,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igHznProfLongLR_0",   /*sig_name*/"isHznProfLongLRProfileType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/404,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/139,   /*updatebit_D*/176         },
           {   /*sigGroup_s*/"igChrgnUReqSec_0",   /*sig_name*/"isChrgnUReqSecCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/85,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x16f, /*updatebit_S*/81,   /*updatebit_D*/491         },
           {   /*sigGroup_s*/"igChrgnUReqSec_0",   /*sig_name*/"isChrgnUReqSecChrgnUReq_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/77,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/487,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x16f, /*updatebit_S*/81,   /*updatebit_D*/491         },
           {   /*sigGroup_s*/"igChrgnUReqSec_0",   /*sig_name*/"isChrgnUReqSecChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/69,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x16f, /*updatebit_S*/81,   /*updatebit_D*/491         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRPositionConfidence_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRMessageType_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/114,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/338,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRCurrentLane_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/117,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/341,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRSpeed_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRPathIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/96,   /*sigG_length*/6,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/320,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLROffset_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRCyclicCounter_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/124,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/348,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRPositionIndex_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/122,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/346,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRPositionAge_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/74,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRRelativeHeading_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/88,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         },
           {   /*sigGroup_s*/"igHznPosnLR_0",   /*sig_name*/"isHznPosnLRPositionProbability_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/106,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/330,    /*src_cyc*/101,  /*src_id*/0x1b3,   /*src_dlc*/64,   /*des_id*/0x23d, /*updatebit_S*/120,   /*updatebit_D*/344         }
       }
   },
   {
       /*des_can*/ "ZCUD_CAN1",
       /*networktype*/ "CAN",
       30,
       {
           {   /*sigGroup_s*/"igThrdRowLeSeatDispMassgFct_0",   /*sig_name*/"isThrdRowLeSeatDispMassgFctMassgInten_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/204,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/200,   /*updatebit_D*/48         },
           {   /*sigGroup_s*/"igThrdRowLeSeatDispMassgFct_0",   /*sig_name*/"isThrdRowLeSeatDispMassgFctMassgProg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/200,   /*updatebit_D*/48         },
           {   /*sigGroup_s*/"igThrdRowLeSeatDispMassgFct_0",   /*sig_name*/"isThrdRowLeSeatDispMassgFctOnOffl2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/202,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/200,   /*updatebit_D*/48         },
           {   /*sigGroup_s*/"igPosnBrief_0",   /*sig_name*/"isPosnBriefPosnLat_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/30,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_id*/0x143, /*updatebit_S*/82,   /*updatebit_D*/6         },
           {   /*sigGroup_s*/"igPosnBrief_0",   /*sig_name*/"isPosnBriefPosnLgt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/31,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x4c0,   /*src_dlc*/64,   /*des_id*/0x143, /*updatebit_S*/82,   /*updatebit_D*/6         },
           {   /*sigGroup_s*/"igThrdRowRiSeatDispMassgFct_0",   /*sig_name*/"isThrdRowRiSeatDispMassgFctMassgInten_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/208,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igThrdRowRiSeatDispMassgFct_0",   /*sig_name*/"isThrdRowRiSeatDispMassgFctOnOffl2_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/210,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/208,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igThrdRowRiSeatDispMassgFct_0",   /*sig_name*/"isThrdRowRiSeatDispMassgFctMassgProg_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/215,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x321,   /*src_dlc*/64,   /*des_id*/0x32f, /*updatebit_S*/208,   /*updatebit_D*/56         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosFrntHeiPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosHeiPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/173,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosSldQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/197,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosFrntHeiQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/185,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosSldPerc_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/179,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igPassSeatPosPerc_0",   /*sig_name*/"isPassSeatPosPercSeatPosHeiQF_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/199,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x260,   /*src_dlc*/64,   /*des_id*/0x398, /*updatebit_S*/195,   /*updatebit_D*/2         },
           {   /*sigGroup_s*/"igAmbTEstimd_0",   /*sig_name*/"isAmbTEstimdAmbTEstimd_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/207,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/128,   /*updatebit_D*/5         },
           {   /*sigGroup_s*/"igAmbTEstimd_0",   /*sig_name*/"isAmbTEstimdQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/212,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x150,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/128,   /*updatebit_D*/5         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/217,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/227,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowFirstLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/231,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowFirstRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/221,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowSecRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/225,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatVentnForRowFirstRi_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/229,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowSecLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/219,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igSeatClimaDurgClima_0",   /*sig_name*/"isSeatClimaDurgClimaHmiSeatHeatgForRowFirstLe_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/223,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x2f0,   /*src_dlc*/64,   /*des_id*/0x490, /*updatebit_S*/16,   /*updatebit_D*/63         },
           {   /*sigGroup_s*/"igCmptmtTRe_0",   /*sig_name*/"isCmptmtTReCmptmtTFrntQf_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x271, /*updatebit_S*/41,   /*updatebit_D*/17         },
           {   /*sigGroup_s*/"igCmptmtTRe_0",   /*sig_name*/"isCmptmtTReCmptmtTFrnt_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/11,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x271, /*updatebit_S*/41,   /*updatebit_D*/17         },
           {   /*sigGroup_s*/"igCmptmtTRe_0",   /*sig_name*/"isCmptmtTReFanForCmptmtTRunng_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x2c8,   /*src_dlc*/64,   /*des_id*/0x271, /*updatebit_S*/41,   /*updatebit_D*/17         },
           {   /*sigGroup_s*/"igBattFltStsSec_0",   /*sig_name*/"isBattFltStsSecBattFltStsPrm_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x99, /*updatebit_S*/176,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igBattFltStsSec_0",   /*sig_name*/"isBattFltStsSecChks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x99, /*updatebit_S*/176,   /*updatebit_D*/16         },
           {   /*sigGroup_s*/"igBattFltStsSec_0",   /*sig_name*/"isBattFltStsSecCntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x99, /*updatebit_S*/176,   /*updatebit_D*/16         }
       }
   },
   {
       /*des_can*/ "ZCUD_CANFD4",
       /*networktype*/ "CANFD",
       16,
       {
           {   /*sigGroup_s*/"igDoorPassPosnToObst2_0",   /*sig_name*/"isDoorPassPosnToObst2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/290,   /*updatebit_D*/107         },
           {   /*sigGroup_s*/"igDoorPassPosnToObst2_0",   /*sig_name*/"isDoorPassPosnToObst2AngleDeg11_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/95,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/290,   /*updatebit_D*/107         },
           {   /*sigGroup_s*/"igDoorPassPosnToObst2_0",   /*sig_name*/"isDoorPassPosnToObst2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/103,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/290,   /*updatebit_D*/107         },
           {   /*sigGroup_s*/"igDoorPassRePosnToObst2_0",   /*sig_name*/"isDoorPassRePosnToObst2AngleDeg11_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/303,   /*updatebit_D*/171         },
           {   /*sigGroup_s*/"igDoorPassRePosnToObst2_0",   /*sig_name*/"isDoorPassRePosnToObst2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/183,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/303,   /*updatebit_D*/171         },
           {   /*sigGroup_s*/"igDoorPassRePosnToObst2_0",   /*sig_name*/"isDoorPassRePosnToObst2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/175,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/303,   /*updatebit_D*/171         },
           {   /*sigGroup_s*/"igDoorPassReObstPos2_0",   /*sig_name*/"isDoorPassReObstPos2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/107,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/300,   /*updatebit_D*/147         },
           {   /*sigGroup_s*/"igDoorPassReObstPos2_0",   /*sig_name*/"isDoorPassReObstPos2ObjectPosZ_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/300,   /*updatebit_D*/147         },
           {   /*sigGroup_s*/"igDoorPassReObstPos2_0",   /*sig_name*/"isDoorPassReObstPos2ObjectPosY_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/123,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/300,   /*updatebit_D*/147         },
           {   /*sigGroup_s*/"igDoorPassReObstPos2_0",   /*sig_name*/"isDoorPassReObstPos2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/139,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/300,   /*updatebit_D*/147         },
           {   /*sigGroup_s*/"igDoorPassReObstPos2_0",   /*sig_name*/"isDoorPassReObstPos2ObjectPosX_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/115,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/300,   /*updatebit_D*/147         },
           {   /*sigGroup_s*/"igDoorPassObstPos2_0",   /*sig_name*/"isDoorPassObstPos2ObjectPosZ_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/288,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igDoorPassObstPos2_0",   /*sig_name*/"isDoorPassObstPos2Chks_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/288,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igDoorPassObstPos2_0",   /*sig_name*/"isDoorPassObstPos2ObjectPosY_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/288,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igDoorPassObstPos2_0",   /*sig_name*/"isDoorPassObstPos2Cntr_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/288,   /*updatebit_D*/83         },
           {   /*sigGroup_s*/"igDoorPassObstPos2_0",   /*sig_name*/"isDoorPassObstPos2ObjectPosX_0",   /*src_can*/"ZCU_CANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x135,   /*src_dlc*/64,   /*des_id*/0x50, /*updatebit_S*/288,   /*updatebit_D*/83         }
       }
   },
   {
       /*des_can*/ "ZCU_CANFD2",
       /*networktype*/ "CANFD",
       2427,
       {
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsCtrlSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsDegraded_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsADMod_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igADL3LatCtrlSts_0",   /*sig_name*/"isADL3LatCtrlStsChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0xf6,   /*src_dlc*/8,   /*des_id*/0x5a, /*updatebit_S*/23,   /*updatebit_D*/232         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/298,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/274,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/257,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/273,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/304,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/281,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/268,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/297,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/286,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/315,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/280,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/292,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/270,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/265,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/314,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/305,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/261,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/299,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/284,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/285,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/291,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/278,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/308,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/277,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/282,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/313,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/258,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/259,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/275,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/289,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/296,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/309,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/300,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/288,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/276,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/316,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/318,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/256,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/266,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/302,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/306,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/310,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/290,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/293,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/294,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/301,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/312,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/283,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/307,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/317,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMBL_0",   /*sig_name*/"isVFCVectorSMBLVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/264,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1MaxRackPosnLe_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/73,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/169,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1RackMtrTrq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/18,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/122,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/109,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1RackFEstimdVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/132,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1AgCtrlPath_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/126,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1ActRackPosn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/133,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1TarRackPosnAtADAS_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1ActRackPosnQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/134,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1ActRackPosnVel_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1MaxRackPosnRi_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/91,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1RackMtrTrqVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1PwrCpFac_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/117,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igPubCANRWA1Group1_0",   /*sig_name*/"isPubCANRWA1Group1RackFEstimd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x31,   /*src_dlc*/32,   /*des_id*/0x180, /*updatebit_S*/130,   /*updatebit_D*/226         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid56_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid54_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid17_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid10_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid1_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid28_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid58_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid16_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid22_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid53_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid19_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid57_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid21_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid46_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid52_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid12_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid23_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid38_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid26_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid47_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid6_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid0_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid2_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMBlockID_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid50_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid55_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid18_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid48_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid34_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid37_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid9_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid32_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid15_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid42_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid30_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid11_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid31_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid49_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid51_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid4_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid7_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid24_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid33_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid20_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid59_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid45_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid3_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid61_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid40_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid27_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid25_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid60_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid5_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid39_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid44_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid13_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid36_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid35_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid29_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid43_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid41_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid8_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRDRM_0",   /*sig_name*/"isVFCVectorRDRMVFCid14_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x545,   /*src_dlc*/8,   /*des_id*/0x489, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/287,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Chk_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/272,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igEPBLockChk2_0",   /*sig_name*/"isEPBLockChk2Data1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/295,    /*src_cyc*/101,  /*src_id*/0x250,   /*src_dlc*/64,   /*des_id*/0x180, /*updatebit_S*/62,   /*updatebit_D*/80         },
           {   /*sigGroup_s*/"igOHCThirdRowBtnErrSts_0",   /*sig_name*/"isOHCThirdRowBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/240         },
           {   /*sigGroup_s*/"igOHCThirdRowBtnErrSts_0",   /*sig_name*/"isOHCThirdRowBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/240         },
           {   /*sigGroup_s*/"igOHCFrBtnErrSts_0",   /*sig_name*/"isOHCFrBtnErrStsLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igOHCFrBtnErrSts_0",   /*sig_name*/"isOHCFrBtnErrStsIntrLiSwtAutOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igOHCFrBtnErrSts_0",   /*sig_name*/"isOHCFrBtnErrStsIntrLiSwtAllOnSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igOHCFrBtnErrSts_0",   /*sig_name*/"isOHCFrBtnErrStsLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/235         },
           {   /*sigGroup_s*/"igRowSecRiLegRstHeiPosPerc_0",   /*sig_name*/"isRowSecRiLegRstHeiPosPercSeatPosQf_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/269,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/12,   /*updatebit_D*/267         },
           {   /*sigGroup_s*/"igRowSecRiLegRstHeiPosPerc_0",   /*sig_name*/"isRowSecRiLegRstHeiPosPercSeatPosPerc_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/10,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/0x24a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/12,   /*updatebit_D*/267         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid60_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid34_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid53_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid37_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid12_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid17_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHWAM_0",   /*sig_name*/"isVFCVectorHWAMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x54a,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igDoorDrvrObstPos2_0",   /*sig_name*/"isDoorDrvrObstPos2ObjectPosX_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igDoorDrvrObstPos2_0",   /*sig_name*/"isDoorDrvrObstPos2ObjectPosY_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igDoorDrvrObstPos2_0",   /*sig_name*/"isDoorDrvrObstPos2Chks_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igDoorDrvrObstPos2_0",   /*sig_name*/"isDoorDrvrObstPos2Cntr_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igDoorDrvrObstPos2_0",   /*sig_name*/"isDoorDrvrObstPos2ObjectPosZ_0",   /*src_can*/"ZCUD_CANFD4",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x60,   /*src_dlc*/64,   /*des_id*/0x132, /*updatebit_S*/35,   /*updatebit_D*/443         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2CurtMotHallNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igReSunCurtFailrSRM2_0",   /*sig_name*/"isReSunCurtFailrSRM2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/41         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltTmrFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltActrFlt5_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/475,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltActrFlt4_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/476,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltActrFlt3_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/477,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltActrFlt2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/478,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igActvReSplrIntFlt_0",   /*sig_name*/"isActvReSplrIntFltActrFlt1_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/473         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotHallFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotHallNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2EcuFailrGen_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotFailr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2Resvd_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igFrntSunCurtFailrSRM2_0",   /*sig_name*/"isFrntSunCurtFailrSRM2CurtMotNotAvl_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/35,   /*src_dlc*/8,   /*des_id*/0x180, /*updatebit_S*/1000,   /*updatebit_D*/33         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndFltngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/385,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndDisSldngDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/390,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndDriveOpnDoorWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/389,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndPreConNotFulfil_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/384,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndFltAndPitchWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/386,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndStpDurngMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndEndNotSuccssWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndStrMovngWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/398,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igSldngRiReWarnInd_0",   /*sig_name*/"isSldngRiReWarnIndDurngDoorMovWarn_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/388,    /*src_cyc*/101,  /*src_id*/0x133,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/23,   /*updatebit_D*/461         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1DrvrSteerWhlHld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/136,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/136,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1SteerAstLvl_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/132,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/132,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1SteerSftyLimrSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/159,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1TarRackPosnQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/148,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/148,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1TarRackPosnVel_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/79,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1DrvrSteerActv_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/145,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/145,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1DrvrInpFac_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/97,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1Cntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColAgQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/142,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/142,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1AlignmentSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/146,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/146,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1Chks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/81,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1HwaSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/89,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1PwrCpVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/144,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColAg_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1TankTurnSteerWhlCfm_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/129,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/129,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1TarRackPosn_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ActrCtrlSts_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/115,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1DrvrTq_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColTqQf_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/140,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/140,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ADASLvlCfmd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColAgSpd_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1SteerStsToCrabMov_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/150,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/150,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1DrvrSteerWhlHldQly_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/123,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1PwrCp_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/106,   /*sigG_length*/7,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igPubCANHWA1Group1_0",   /*sig_name*/"isPubCANHWA1Group1ColTqVld_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/138,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/138,    /*src_cyc*/101,  /*src_id*/0x21,   /*src_dlc*/32,   /*des_id*/0x132, /*updatebit_S*/158,   /*updatebit_D*/458         },
           {   /*sigGroup_s*/"igRWA2SysStsR2_0",   /*sig_name*/"isRWA2SysStsR2MaiSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/474,    /*src_cyc*/101,  /*src_id*/0x177,   /*src_dlc*/8,   /*des_id*/0x281, /*updatebit_S*/15,   /*updatebit_D*/111         },
           {   /*sigGroup_s*/"igRWA2SysStsR2_0",   /*sig_name*/"isRWA2SysStsR2FctModCfmd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/479,    /*src_cyc*/101,  /*src_id*/0x177,   /*src_dlc*/8,   /*des_id*/0x281, /*updatebit_S*/15,   /*updatebit_D*/111         },
           {   /*sigGroup_s*/"igTVCRwsAngReqForTvc_0",   /*sig_name*/"isTVCRwsAngReqForTvcChks_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/144,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/28,   /*updatebit_D*/164         },
           {   /*sigGroup_s*/"igTVCRwsAngReqForTvc_0",   /*sig_name*/"isTVCRwsAngReqForTvcCntr_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/152,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/28,   /*updatebit_D*/164         },
           {   /*sigGroup_s*/"igTVCRwsAngReqForTvc_0",   /*sig_name*/"isTVCRwsAngReqForTvcTVCRwsAngReqForTvc_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/143,    /*src_cyc*/101,  /*src_id*/0x51,   /*src_dlc*/64,   /*des_id*/0x1cf, /*updatebit_S*/28,   /*updatebit_D*/164         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone5_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone6_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone2_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone3_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone1_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igReadLiIntensityVal_0",   /*sig_name*/"isReadLiIntensityValZone4_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/5,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/6,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/25         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid18_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid53_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/112,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid40_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid42_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid48_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid43_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid15_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid20_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid27_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid32_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid51_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid38_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid58_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid55_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid10_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid49_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid12_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/73,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid47_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid54_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid61_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid25_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid29_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid19_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid37_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/96,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid21_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid22_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid45_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid52_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid30_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid23_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid57_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid60_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/121,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid39_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid31_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid34_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/99,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid35_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid36_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid9_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid59_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid44_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid8_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid28_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid13_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid41_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid14_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid17_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/84,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid50_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid16_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid46_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMBlockID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid11_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid33_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid26_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid24_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorRBCM_0",   /*sig_name*/"isVFCVectorRBCMVFCid56_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x575,   /*src_dlc*/8,   /*des_id*/0x4b5, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igPtBrkTqReqToFri_0",   /*sig_name*/"isPtBrkTqReqToFriChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/72,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/416,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/498,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igPtBrkTqReqToFri_0",   /*sig_name*/"isPtBrkTqReqToFriQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/92,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/436,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/498,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igPtBrkTqReqToFri_0",   /*sig_name*/"isPtBrkTqReqToFriPtBrkTqRgnAtAxleReAct_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/71,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/498,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igPtBrkTqReqToFri_0",   /*sig_name*/"isPtBrkTqReqToFriCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/80,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/424,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x5a, /*updatebit_S*/498,   /*updatebit_D*/434         },
           {   /*sigGroup_s*/"igDtEngdSt_0",   /*sig_name*/"isDtEngdStDtEngdRe_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/166,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x3d0, /*updatebit_S*/208,   /*updatebit_D*/99         },
           {   /*sigGroup_s*/"igDtEngdSt_0",   /*sig_name*/"isDtEngdStDtEngdFrnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/167,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x3d0, /*updatebit_S*/208,   /*updatebit_D*/99         },
           {   /*sigGroup_s*/"igDtEngdSt_0",   /*sig_name*/"isDtEngdStDtNotEngdRe_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/164,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x3d0, /*updatebit_S*/208,   /*updatebit_D*/99         },
           {   /*sigGroup_s*/"igDtEngdSt_0",   /*sig_name*/"isDtEngdStDtNotEngdFrnt_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/165,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0xde,   /*src_dlc*/64,   /*des_id*/0x3d0, /*updatebit_S*/208,   /*updatebit_D*/99         },
           {   /*sigGroup_s*/"igRWA2EgyCnsGroup_0",   /*sig_name*/"isRWA2EgyCnsGroupIVal_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/260,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/26,   /*updatebit_D*/282         },
           {   /*sigGroup_s*/"igRWA2EgyCnsGroup_0",   /*sig_name*/"isRWA2EgyCnsGroupUval_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/279,    /*src_cyc*/101,  /*src_id*/0x13b,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/26,   /*updatebit_D*/282         },
           {   /*sigGroup_s*/"igAmbIllmnFwdSts_0",   /*sig_name*/"isAmbIllmnFwdStsCntr_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/58         },
           {   /*sigGroup_s*/"igAmbIllmnFwdSts_0",   /*sig_name*/"isAmbIllmnFwdStsAmblillmn1_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/58         },
           {   /*sigGroup_s*/"igAmbIllmnFwdSts_0",   /*sig_name*/"isAmbIllmnFwdStsAmblillmn2_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/58         },
           {   /*sigGroup_s*/"igAmbIllmnFwdSts_0",   /*sig_name*/"isAmbIllmnFwdStsChks_0",   /*src_can*/"CEM_LIN1",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/44,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/58         },
           {   /*sigGroup_s*/"igDoorSldngLeReSts_0",   /*sig_name*/"isDoorSldngLeReStsDoorOpenSts_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/495,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/32,   /*updatebit_D*/490         },
           {   /*sigGroup_s*/"igDoorSldngLeReSts_0",   /*sig_name*/"isDoorSldngLeReStsFrstTmLveAbnd_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/491,    /*src_cyc*/101,  /*src_id*/0x12e,   /*src_dlc*/8,   /*des_id*/0x170, /*updatebit_S*/32,   /*updatebit_D*/490         },
           {   /*sigGroup_s*/"igParkByDrvrWhlsFrntSafe_0",   /*sig_name*/"isParkByDrvrWhlsFrntSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/395,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igParkByDrvrWhlsFrntSafe_0",   /*sig_name*/"isParkByDrvrWhlsFrntSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/395,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igParkByDrvrWhlsFrntSafe_0",   /*sig_name*/"isParkByDrvrWhlsFrntSafeSts_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/387,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/323,    /*src_cyc*/101,  /*src_id*/0xe4,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/395,   /*updatebit_D*/322         },
           {   /*sigGroup_s*/"igSteerWhlSnsr_0",   /*sig_name*/"isSteerWhlSnsrChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/177,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/7,   /*updatebit_D*/464         },
           {   /*sigGroup_s*/"igSteerWhlSnsr_0",   /*sig_name*/"isSteerWhlSnsrQf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/7,   /*updatebit_D*/464         },
           {   /*sigGroup_s*/"igSteerWhlSnsr_0",   /*sig_name*/"isSteerWhlSnsrAgSpd_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/14,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/7,   /*updatebit_D*/464         },
           {   /*sigGroup_s*/"igSteerWhlSnsr_0",   /*sig_name*/"isSteerWhlSnsrCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/7,   /*updatebit_D*/464         },
           {   /*sigGroup_s*/"igSteerWhlSnsr_0",   /*sig_name*/"isSteerWhlSnsrAg_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/15,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/0x40,   /*src_dlc*/8,   /*des_id*/0x132, /*updatebit_S*/7,   /*updatebit_D*/464         },
           {   /*sigGroup_s*/"igWhlMotSysRiSpdActSafe_0",   /*sig_name*/"isWhlMotSysRiSpdActSafeChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/127,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/431,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/129,   /*updatebit_D*/406         },
           {   /*sigGroup_s*/"igWhlMotSysRiSpdActSafe_0",   /*sig_name*/"isWhlMotSysRiSpdActSafeIsgSpdActSgn800_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/111,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/129,   /*updatebit_D*/406         },
           {   /*sigGroup_s*/"igWhlMotSysRiSpdActSafe_0",   /*sig_name*/"isWhlMotSysRiSpdActSafeCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/135,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/405,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/129,   /*updatebit_D*/406         },
           {   /*sigGroup_s*/"igWhlMotSysRiSpdActSafe_0",   /*sig_name*/"isWhlMotSysRiSpdActSafeQF_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/131,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/401,    /*src_cyc*/101,  /*src_id*/0x5f,   /*src_dlc*/64,   /*des_id*/0x4ee, /*updatebit_S*/129,   /*updatebit_D*/406         },
           {   /*sigGroup_s*/"igSBWErrReqR2_0",   /*sig_name*/"isSBWErrReqR2Chks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/8,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igSBWErrReqR2_0",   /*sig_name*/"isSBWErrReqR2SteerErrReq_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/8,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igSBWErrReqR2_0",   /*sig_name*/"isSBWErrReqR2Cntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/8,   /*updatebit_D*/184         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/319,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/343,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/311,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/327,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockChkSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/303,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igRWASteerLockChk2_0",   /*sig_name*/"isRWASteerLockChk2SteerLockDataChk6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/351,    /*src_cyc*/101,  /*src_id*/0x18e,   /*src_dlc*/8,   /*des_id*/0x1cf, /*updatebit_S*/62,   /*updatebit_D*/358         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimWakeupActvFlg_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/468,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimHiTFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/449,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimUvCellFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/470,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimOvCellFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/463,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimResetActFlg_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/458,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimChks_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/447,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimOcFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/448,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimRlyOpenSoonIndcn_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/457,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimReserved1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/459,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimScFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/456,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimCntr_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/455,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimFaultLevel_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/451,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimOvFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/462,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimThermRunawayFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/471,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimPreThermRunawayFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/461,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimUvFlt_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/469,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igNewBattFltStsPrim_0",   /*sig_name*/"isNewBattFltStsPrimReserved0_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/460,    /*src_cyc*/101,  /*src_id*/33,   /*src_dlc*/4,   /*des_id*/0x2e0, /*updatebit_S*/1000,   /*updatebit_D*/467         },
           {   /*sigGroup_s*/"igPrpsnTqReReq_0",   /*sig_name*/"isPrpsnTqReReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/379,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/377,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igPrpsnTqReReq_0",   /*sig_name*/"isPrpsnTqReReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/383,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/377,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igPrpsnTqReReq_0",   /*sig_name*/"isPrpsnTqReReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/375,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/377,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igPrpsnTqReReq_0",   /*sig_name*/"isPrpsnTqReReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/359,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/135,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/377,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igEgyMeasIntl_0",   /*sig_name*/"isEgyMeasIntlIntl1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/167,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/432         },
           {   /*sigGroup_s*/"igEgyMeasIntl_0",   /*sig_name*/"isEgyMeasIntlIntl2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/175,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/432         },
           {   /*sigGroup_s*/"igEgyMeasIntl_0",   /*sig_name*/"isEgyMeasIntlIntl4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/432         },
           {   /*sigGroup_s*/"igEgyMeasIntl_0",   /*sig_name*/"isEgyMeasIntlIntl3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/40,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/432         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSts_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/415,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk4_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/391,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk0_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/359,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/375,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk6_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/407,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk3_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/383,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igSteerLockChk_0",   /*sig_name*/"isSteerLockChkSteerLockDataChk5_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/399,    /*src_cyc*/101,  /*src_id*/0x2a0,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/1,   /*updatebit_D*/414         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid16_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/21,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid4_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/1,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid30_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/39,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid50_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/51,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid46_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/55,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid36_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/33,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid45_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/40,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid47_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/54,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid49_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/52,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid18_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/19,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid32_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/37,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid38_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/47,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid15_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/22,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid19_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/18,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid42_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/43,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid20_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/17,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid0_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/5,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid10_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/11,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid53_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/48,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid41_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/44,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid24_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/29,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid13_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/8,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid25_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/28,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid8_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/13,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid1_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/4,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid9_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/12,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid54_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/63,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid40_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/45,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid56_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/61,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid57_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/60,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid7_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/14,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid31_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/38,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid2_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/3,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid14_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/23,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid27_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/26,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid26_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/27,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid44_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/41,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid28_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/25,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid61_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/56,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid60_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/57,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid51_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/50,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid23_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/30,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid12_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/9,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid34_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/35,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid3_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/2,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid17_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/20,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid52_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/49,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid55_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/62,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid11_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/10,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid21_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/16,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid33_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/36,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid22_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/31,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid39_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/46,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid35_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/34,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid37_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/32,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid48_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/53,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid5_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/0,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid58_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/59,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid6_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/15,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADBlockID_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/7,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid43_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/42,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid29_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/24,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorDSAD_0",   /*sig_name*/"isVFCVectorDSADVFCid59_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/58,    /*src_cyc*/101,  /*src_id*/0x559,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igBtnStsOHCR_0",   /*sig_name*/"isBtnStsOHCRLiBtnReadingRi_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igBtnStsOHCR_0",   /*sig_name*/"isBtnStsOHCRLiBtnReadingLe_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/216         },
           {   /*sigGroup_s*/"igPassAirbLampStsRec_0",   /*sig_name*/"isPassAirbLampStsRecPassAirbLampStsCntr_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/271,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/265         },
           {   /*sigGroup_s*/"igPassAirbLampStsRec_0",   /*sig_name*/"isPassAirbLampStsRecPassAirbLampStsChks_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/263,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/265         },
           {   /*sigGroup_s*/"igPassAirbLampStsRec_0",   /*sig_name*/"isPassAirbLampStsRecPassAirbLampSts_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/267,    /*src_cyc*/101,  /*src_id*/32,   /*src_dlc*/7,   /*des_id*/0x4c3, /*updatebit_S*/1000,   /*updatebit_D*/265         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltTmrFlt_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/154,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltActrFlt4_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/156,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltActrFlt1_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltActrFlt3_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/157,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltActrFlt5_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igElecStepFlt_0",   /*sig_name*/"isElecStepFltActrFlt2_0",   /*src_can*/"CEM_LIN7",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/158,    /*src_cyc*/101,  /*src_id*/17,   /*src_dlc*/8,   /*des_id*/0x1e5, /*updatebit_S*/1000,   /*updatebit_D*/153         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid23_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/222,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid59_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/250,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid9_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/204,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid39_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/238,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid43_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/234,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid1_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid51_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/242,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid19_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/210,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid4_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/6,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid55_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/57,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/254,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid2_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid48_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/245,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid34_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/227,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid28_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/217,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid22_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/223,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid17_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/212,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid33_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/228,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid5_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid21_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/208,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid26_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/219,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid44_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/233,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid56_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/253,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid31_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/230,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid58_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/251,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid30_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/231,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid20_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/209,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid52_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/241,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid42_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/235,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid15_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/214,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid46_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/247,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid7_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/9,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid13_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/200,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid36_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/225,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid45_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/232,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid24_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/221,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid53_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/240,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid18_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/211,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid8_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid14_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/215,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid61_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/248,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid10_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/203,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid16_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/213,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid54_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/255,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid40_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/237,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid3_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid0_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid32_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/229,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid60_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/249,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid35_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/226,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid12_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/201,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid37_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/224,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid57_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/252,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid47_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/246,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid27_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/218,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid11_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/202,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid38_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/239,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBBlockID_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid49_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/244,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid50_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/243,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid29_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/216,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid6_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid25_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/220,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorSMB_0",   /*sig_name*/"isVFCVectorSMBVFCid41_0",   /*src_can*/"ZCUD_CAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/236,    /*src_cyc*/101,  /*src_id*/0x554,   /*src_dlc*/8,   /*des_id*/0x4b1, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igTrsmCluT1_0",   /*sig_name*/"isTrsmCluT1Val_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/9,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/335,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/3,   /*updatebit_D*/340         },
           {   /*sigGroup_s*/"igTrsmCluT1_0",   /*sig_name*/"isTrsmCluT1Qf_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/342,    /*src_cyc*/101,  /*src_id*/0x15a,   /*src_dlc*/8,   /*des_id*/0x4c6, /*updatebit_S*/3,   /*updatebit_D*/340         },
           {   /*sigGroup_s*/"igSBWFltStsR2_0",   /*sig_name*/"isSBWFltStsR2FltStsH1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/367,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/19,   /*updatebit_D*/363         },
           {   /*sigGroup_s*/"igSBWFltStsR2_0",   /*sig_name*/"isSBWFltStsR2FltStsR1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/19,   /*updatebit_D*/363         },
           {   /*sigGroup_s*/"igSBWFltStsR2_0",   /*sig_name*/"isSBWFltStsR2FltStsH2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/366,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/19,   /*updatebit_D*/363         },
           {   /*sigGroup_s*/"igSBWFltStsR2_0",   /*sig_name*/"isSBWFltStsR2FltStsR2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/20,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/364,    /*src_cyc*/101,  /*src_id*/0x15c,   /*src_dlc*/8,   /*des_id*/0x2e3, /*updatebit_S*/19,   /*updatebit_D*/363         },
           {   /*sigGroup_s*/"igFloatDrvingActv_0",   /*sig_name*/"isFloatDrvingActvChks_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/151,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/32,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igFloatDrvingActv_0",   /*sig_name*/"isFloatDrvingActvStatus_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/35,   /*sigG_length*/3,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/155,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/32,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igFloatDrvingActv_0",   /*sig_name*/"isFloatDrvingActvCntr_0",   /*src_can*/"PropulsionCAN",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/159,    /*src_cyc*/101,  /*src_id*/0x22a,   /*src_dlc*/8,   /*des_id*/0x1c5, /*updatebit_S*/32,   /*updatebit_D*/152         },
           {   /*sigGroup_s*/"igBattULiCell_0",   /*sig_name*/"isBattULiCellBattUCell4_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/406,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/409         },
           {   /*sigGroup_s*/"igBattULiCell_0",   /*sig_name*/"isBattULiCellBattUCell2_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/368,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/409         },
           {   /*sigGroup_s*/"igBattULiCell_0",   /*sig_name*/"isBattULiCellBattUCell1_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/365,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/409         },
           {   /*sigGroup_s*/"igBattULiCell_0",   /*sig_name*/"isBattULiCellBattUCell3_0",   /*src_can*/"CEM_LIN6",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/32,   /*sigG_length*/13,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/387,    /*src_cyc*/101,  /*src_id*/7,   /*src_dlc*/8,   /*des_id*/0x4d1, /*updatebit_S*/1000,   /*updatebit_D*/409         },
           {   /*sigGroup_s*/"igActvReSplrUFlt_0",   /*sig_name*/"isActvReSplrUFltLoVoltDetdFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/482,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/481         },
           {   /*sigGroup_s*/"igActvReSplrUFlt_0",   /*sig_name*/"isActvReSplrUFltHiVoltDetdFlt_0",   /*src_can*/"CEM_LIN3",   /*src_network_type*/"LIN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/483,    /*src_cyc*/101,  /*src_id*/26,   /*src_dlc*/3,   /*des_id*/0x1c5, /*updatebit_S*/1000,   /*updatebit_D*/481         },
           {   /*sigGroup_s*/"igPrpsnTqFrntReq_0",   /*sig_name*/"isPrpsnTqFrntReqTq_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/391,   /*sigG_length*/16,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/409,   /*updatebit_D*/121         },
           {   /*sigGroup_s*/"igPrpsnTqFrntReq_0",   /*sig_name*/"isPrpsnTqFrntReqQf_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/411,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/409,   /*updatebit_D*/121         },
           {   /*sigGroup_s*/"igPrpsnTqFrntReq_0",   /*sig_name*/"isPrpsnTqFrntReqCntr_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/415,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/409,   /*updatebit_D*/121         },
           {   /*sigGroup_s*/"igPrpsnTqFrntReq_0",   /*sig_name*/"isPrpsnTqFrntReqChks_0",   /*src_can*/"ChassisCANFD2",   /*src_network_type*/"CANFD",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/407,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x7c,   /*src_dlc*/64,   /*des_id*/0x4d1, /*updatebit_S*/409,   /*updatebit_D*/121         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtModBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/197,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtDwnBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/185,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtCmfBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/187,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtCustBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/186,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtRiBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/48,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/192,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtUpBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/207,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtVoiceBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/205,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtLeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/199,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtViewBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/206,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtReserveBtn1_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/194,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtHomeBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/184,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtCntr_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/4,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/191,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtMuteBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/196,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtChks_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/8,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/183,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtMenuBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/198,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtBoostBtn_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/195,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igSteerWhlEntertainmentSwt_0",   /*sig_name*/"isSteerWhlEntertainmentSwtReserveBtn2_0",   /*src_can*/"ChassisCAN1",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/193,    /*src_cyc*/101,  /*src_id*/0x187,   /*src_dlc*/8,   /*des_id*/0x80, /*updatebit_S*/24,   /*updatebit_D*/204         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid45_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/40,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/104,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid43_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/42,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/106,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid35_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/34,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/98,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid28_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/25,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/89,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid61_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/56,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/120,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid19_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/18,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/82,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid18_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/19,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/83,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid58_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/59,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/123,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid46_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/55,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/119,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid47_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/54,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/118,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid29_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/24,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/88,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid51_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/50,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/114,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid52_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/49,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/113,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid23_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/30,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/94,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid42_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/43,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/107,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid2_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/3,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/67,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid3_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/2,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/66,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid16_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/21,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/85,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid5_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/0,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/64,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid31_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/38,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/102,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid21_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/16,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/80,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid25_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/28,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/92,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid0_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/5,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/69,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid44_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/41,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/105,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid20_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/17,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/81,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid10_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/11,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/75,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid38_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/47,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/111,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid6_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/15,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/79,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid1_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/4,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/68,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid4_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/1,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/65,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid14_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/23,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/87,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid26_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/27,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/91,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid50_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/51,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/115,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid27_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/26,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/90,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid48_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/53,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/117,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid33_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/36,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/100,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid11_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/10,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/74,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid40_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/45,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/109,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid39_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/46,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/110,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid49_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/52,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/116,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid57_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/60,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/124,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid41_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/44,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/108,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid32_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/37,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/101,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid9_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/12,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/76,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid30_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/39,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/103,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid7_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/14,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/78,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid15_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/22,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/86,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid54_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/63,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/127,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid36_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/33,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/97,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid59_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/58,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/122,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid55_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/62,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/126,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid13_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/8,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/72,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid24_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/29,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/93,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid8_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/13,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/77,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid22_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/31,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/95,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMVFCid56_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/61,   /*sigG_length*/1,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/125,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
           {   /*sigGroup_s*/"igVFCVectorHVFM_0",   /*sig_name*/"isVFCVectorHVFMBlockID_0",   /*src_can*/"ZCUD_CANFD3",   /*src_network_type*/"CAN",   /*src_slotid_fr*/0,   /*src_basecycle_fr*/0,  /*src_repetition_fr*/0,  /*src_startbit*/7,   /*sigG_length*/2,  /*des_slotid_fr*/0,   /*des_basecycle_fr*/0,  /*des_repetition_fr*/0,   /*des_startbit*/71,    /*src_cyc*/101,  /*src_id*/0x549,   /*src_dlc*/8,   /*des_id*/0x4bb, /*updatebit_S*/1000,   /*updatebit_D*/1000         },
